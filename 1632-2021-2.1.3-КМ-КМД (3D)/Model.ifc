Properties of the parts of a building model (IFC2X3), part 1 of 3

# File
Description: ViewDefinition[CoordinationView_V2.0], ExchangeRequirement[Structural, SurfaceGeometry]
File name: Model.ifc
Time: 2025-06-23T13:21:33
Author: pc9\Пользователь
Organization: Structural Designer
Written by: IFC Database version:Work
Made in: Tekla structures 21.1 Service Release 2, IFC Export Version: 4.0.0.0 Nov 17 2015

# IfcSite, Undefined
RefElevation: 0 mm

# IfcBuildingStorey, Undefined
In: Undefined
Elevation: 0 mm

# IfcBeam: ДВУТAВР20Ш1 (24)
In: Undefined
Description: ДВУТAВР20Ш1; Material: STEEL/C255-4
Pset_BeamCommon - LoadBearing: yes
Name | Reference
4 x Балка | 1553
16 x Балка | 1552
2 x Балка | 852
2 x Балка | 851

# IfcBeam: ДВУТAВР25К1 (59)
In: Undefined
Description: ДВУТAВР25К1; Material: STEEL/C255-4
Pset_BeamCommon - LoadBearing: yes
Name | Reference
18 x Ферма | 1188
2 x Ферма | 1187
Ферма | 442
38 x Ферма | 441

# IfcBeam: ДВУТAВР30Ш1 (191)
In: Undefined
Description: ДВУТAВР30Ш1; Material: STEEL/C255-4
Pset_BeamCommon - LoadBearing: yes
Name | Reference
2 x Кронштейн | 1093
2 x Балка | 1092
20 x Кронштейн | 93
4 x Балка | 99
2 x Балка | 98
4 x Балка | 100
12 x Балка | 1580
2 x Балка | 97
2 x Балка | 96
2 x Балка | 1091
Балка | 1090
Балка | 1087
60 x Колонна | 92
60 x Колонна | 91
Балка | 95
8 x Колонна | 94
4 x Колонна | 1086
4 x Колонна | 90

# IfcBeam: ДВУТAВР40Ш1 (8)
In: Undefined
Description: ДВУТAВР40Ш1; Material: STEEL/C255-4
Pset_BeamCommon - LoadBearing: yes
Name | Reference
4 x Балка | 309
4 x Балка | 1578

# IfcBeam: ДВУТAВР50Ш1 (258)
In: Undefined
Description: ДВУТAВР50Ш1; Material: STEEL/C255-4
Pset_BeamCommon - LoadBearing: yes
Name | Reference
4 x Балка | 670
2 x Балка | 669
142 x Балка | 668
4 x Балка | 1706
12 x Балка | 1438
4 x Балка | 1705
64 x Балка | 1437
8 x Балка | 1439
12 x Балка | 1436
6 x Балка | 667

# IfcBeam: ДВУТAВР60Ш1 (12)
In: Undefined
Description: ДВУТAВР60Ш1; Material: STEEL/C255-4
Pset_BeamCommon - LoadBearing: yes
Name | Reference
5 x Балка | 88
6 x Балка | 81
Балка | 1607

# IfcBeam: ДВУТAВР70Ш1 (2)
In: Undefined
Description: ДВУТAВР70Ш1; Material: STEEL/C255-4
Pset_BeamCommon - LoadBearing: yes; Reference: 388

# IfcBeam: Круг16 (8)
In: Undefined
Description: Круг16; Material: STEEL/C245-4
Pset_BeamCommon - LoadBearing: yes; Reference: 1248

# IfcBeam: Н57-750-0.8 (1106)
In: Undefined
Description: Н57-750-0.8; Material: STEEL/C235
Pset_BeamCommon - LoadBearing: yes
Name | Reference
553 x Профлист | 666
553 x Профлист | 665

# IfcBeam: НС35-1000-0.7 (23)
In: Undefined
Description: НС35-1000-0.7; Material: STEEL/C235
Pset_BeamCommon - LoadBearing: yes
Name | Reference
6 x Профлист | 1016
6 x Профлист | 1015
5 x Профлист | 1557
4 x Профлист | 1558
Профлист | 1014
Профлист | 1013

# IfcBeam: Профиль(кв.)100X100X5.0 (36)
In: Undefined
Description: Профиль(кв.)100X100X5.0; Material: STEEL/C245-4
Pset_BeamCommon - LoadBearing: yes; Reference: 861

# IfcBeam: Профиль(кв.)120X120X5.0 (133)
In: Undefined
Description: Профиль(кв.)120X120X5.0; Material: STEEL/C245-4
Pset_BeamCommon - LoadBearing: yes
Name | Reference
2 x Распорка | 1546
6 x Распорка | 857
34 x Распорка | 856
Распорка | 1807
18 x Распорка | 1545
2 x Распорка | 1544
2 x Распорка | 855
68 x Связь | 853

# IfcBeam: Профиль(кв.)140X140X5.0 (498)
In: Undefined
Description: Профиль(кв.)140X140X5.0; Material: STEEL/C245-4
Pset_BeamCommon - LoadBearing: yes
Name | Reference
Стойка фахверка | 1668
2 x Распорка | 1247
82 x Ригель фахверка | 639
5 x Распорка | 659
3 x Ригель фахверка | 1666
Ригель фахверка | 1667
Ригель фахверка | 1665
8 x Стойка фахверка | 658
2 x Ригель фахверка | 1235
6 x Ригель фахверка | 655
40 x Ригель фахверка | 1239
78 x Ригель фахверка | 634
2 x Ригель фахверка | 1658
4 x Ригель фахверка | 1237
4 x Ригель фахверка | 633
2 x Ригель фахверка | 649
40 x Ригель фахверка | 632
6 x Ригель фахверка | 652
2 x Ригель фахверка | 653
2 x Ригель фахверка | 651
3 x Ригель фахверка | 648
3 x Ригель фахверка | 647
2 x Ригель фахверка | 646
2 x Ригель фахверка | 645
6 x Ригель фахверка | 644
4 x Ригель фахверка | 643
3 x Ригель фахверка | 1662
Ригель фахверка | 1664
4 x Ригель фахверка | 1663
2 x Ригель фахверка | 1234
4 x Ригель фахверка | 1233
12 x Ригель фахверка | 650
6 x Ригель фахверка | 654
12 x Ригель фахверка | 1232
2 x Ригель фахверка | 1660
Ригель фахверка | 1659
Ригель фахверка | 1661
2 x Ригель фахверка | 642
Ригель фахверка | 641
40 x Ригель фахверка | 1243
10 x Ригель фахверка | 1244
4 x Ригель фахверка | 1241
Ригель фахверка | 1245
19 x Ригель фахверка | 640
10 x Ригель фахверка | 1242
Ригель фахверка | 1240
20 x Ригель фахверка | 638
4 x Ригель фахверка | 637
Ригель фахверка | 636
Ригель фахверка | 635
20 x Ригель фахверка | 1238
2 x Ригель фахверка | 1236
2 x Ригель фахверка | 631
Ригель фахверка | 1657

# IfcBeam: Профиль(кв.)160X160X6.0 (150)
In: Undefined
Description: Профиль(кв.)160X160X6.0; Material: STEEL/C245-4
Pset_BeamCommon - LoadBearing: yes
Name | Reference
6 x Распорка | 543
Распорка | 546
Распорка | 1651
18 x Распорка | 1487
2 x Распорка | 1488
2 x Распорка | 1486
33 x Распорка | 545
2 x Распорка | 544
2 x Распорка | 1485
6 x Распорка | 542
32 x Распорка | 541
Распорка | 1650
14 x Распорка | 1482
Распорка | 1649
2 x Распорка | 1483
Распорка | 1484
2 x Распорка | 1481
2 x Распорка | 1480
2 x Распорка | 540
4 x Связь | 1479
4 x Связь | 1478
4 x Связь | 1477
4 x Связь | 1476
2 x Связь | 515
2 x Связь | 514

# IfcBeam: Профиль(кв.)180X180X5.0 (71)
In: Undefined
Description: Профиль(кв.)180X180X5.0; Material: STEEL/C245-4
Pset_BeamCommon - LoadBearing: yes
Name | Reference
Балка | 1644
4 x Распорка | 319
2 x Распорка | 334
4 x Распорка | 329
16 x Распорка | 1145
2 x Распорка | 1146
36 x Распорка | 332
2 x Распорка | 331
2 x Распорка | 330
2 x Распорка | 1645

# IfcBeam: Профиль(пр.)300X200X6.0 (51)
In: Undefined
Description: Профиль(пр.)300X200X6.0; Material: STEEL/C245-4
Pset_BeamCommon - LoadBearing: yes
Name | Reference
5 x Распорка | 509
2 x Распорка | 1085
2 x Распорка | 1084
Распорка | 512
2 x Распорка | 1083
2 x Распорка | 1082
Распорка | 511
36 x Распорка | 510

# IfcBeam: Труба42.3x2.8 (225)
In: Undefined
Description: Труба42.3x2.8; Material: STEEL/C235
Pset_BeamCommon - LoadBearing: yes
Name | Reference
44 x Ограждение | 966
2 x Ограждение | 1817
2 x Ограждение | 1450
Ограждение | 1816
2 x Ограждение | 1812
4 x Ограждение | 1814
2 x Ограждение | 1815
12 x Ограждение | 1813
2 x Ограждение | 1464
2 x Ограждение | 1463
16 x Ограждение | 1462
8 x Ограждение | 1461
2 x Ограждение | 1460
2 x Ограждение | 1457
2 x Ограждение | 1456
14 x Ограждение | 970
6 x Ограждение | 1453
Ограждение | 971
7 x Ограждение | 953
3 x Ограждение | 1452
8 x Ограждение | 1449
12 x Ограждение | 960
8 x Ограждение | 1446
15 x Ограждение | 968
5 x Ограждение | 964
5 x Ограждение | 963
4 x Ограждение | 962
4 x Ограждение | 961
4 x Ограждение | 1443
4 x Ограждение | 1442
Ограждение | 1571
2 x Ограждение | 965
2 x Ограждение | 959
2 x Ограждение | 958
Ограждение | 957
2 x Ограждение | 956
12 x Ограждение | 952

# IfcBeam: Уголок100X63X8 (60)
In: Undefined
Description: Уголок100X63X8; Material: STEEL/C245-4
Pset_BeamCommon - LoadBearing: yes
Name | Reference
Ригель фахверка | 1177
Ригель фахверка | 1174
Ригель фахверка | 1173
5 x Ригель фахверка | 1175
6 x Лестница | 408
17 x Лестница | 407
4 x Лестница | 1178
3 x Ригель фахверка | 1183
4 x Ригель фахверка | 1170
4 x Ригель фахверка | 1169
3 x Ригель фахверка | 1179
4 x Ригель фахверка | 399
Ригель фахверка | 1176
Лестница | 409
Ригель фахверка | 394
Ригель фахверка | 393
Ригель фахверка | 405
Ригель фахверка | 400
Ригель фахверка | 398

# IfcBeam: Уголок125X8 (183)
In: Undefined
Description: Уголок125X8; Material: STEEL/C245-4
Pset_BeamCommon - LoadBearing: yes
Name | Reference
Связь | 1656
3 x Связь | 555
3 x Связь | 553
Связь | 1655
43 x Связь | 548
5 x Связь | 554
Связь | 1654
Связь | 1653
9 x Связь | 550
5 x Связь | 549
2 x Связь | 552
4 x Связь | 551
4 x Связь | 1542
2 x Связь | 1541
2 x Связь | 1540
4 x Связь | 558
2 x Связь | 1539
76 x Связь | 557
2 x Связь | 562
2 x Связь | 561
3 x Связь | 556
4 x Связь | 560
4 x Связь | 559

# IfcBeam: Уголок125X80X8 (152)
In: Undefined
Description: Уголок125X80X8; Material: STEEL/C245-4
Pset_BeamCommon - LoadBearing: yes
Name | Reference
2 x Лестница | 539
5 x Распорка | 537
5 x Распорка | 536
8 x Распорка | 535
2 x Распорка | 538
2 x Распорка | 1647
2 x Распорка | 533
40 x Распорка | 1467
4 x Распорка | 1466
76 x Распорка | 532
2 x Распорка | 1472
4 x Распорка | 534

# IfcBeam: Уголок63X5 (388)
In: Undefined
Description: Уголок63X5; Material: STEEL/C245-4
Pset_BeamCommon - LoadBearing: yes
Name | Reference
278 x Ограждение | 947
Стойка фахверка | 946
Стойка фахверка | 945
Стойка фахверка | 944
Стойка фахверка | 943
4 x Стойка фахверка | 942
4 x Стойка фахверка | 940
4 x Стойка фахверка | 937
4 x Стойка фахверка | 939
90 x Ригель фахверка | 936

# IfcBeam: Швеллер16П (27)
In: Undefined
Description: Швеллер16П; Material: STEEL/C245-4
Pset_BeamCommon - LoadBearing: yes
Name | Reference
20 x Лестница | 872
7 x Лестница | 870

# IfcBeam: Швеллер20П (768)
In: Undefined
Description: Швеллер20П; Material: STEEL/C245-4
Pset_BeamCommon - LoadBearing: yes
Name | Reference
8 x Балка | 1690
4 x Балка | 1696
24 x Балка | 1699
8 x Балка | 1698
Балка | 1697
2 x Балка | 1700
2 x Балка | 1702
Балка | 1691
Балка | 1701
2 x Балка | 1224
6 x Балка | 1205
6 x Лестница | 1222
4 x Балка | 1202
2 x Балка | 1201
2 x Балка | 1204
2 x Лестница | 1214
2 x Лестница | 1212
6 x Балка | 1199
6 x Балка | 1203
2 x Балка | 1200
14 x Балка | 265
15 x Балка | 264
10 x Балка | 273
5 x Балка | 281
86 x Балка | 272
Балка | 275
Балка | 1695
5 x Балка | 1689
6 x Балка | 282
Балка | 280
Балка | 283
20 x Прогон | 1196
120 x Прогон | 1195
39 x Прогон | 267
234 x Прогон | 266
2 x Прогон | 1194
12 x Прогон | 1193
2 x Прогон | 269
12 x Прогон | 268
Прогон | 263
5 x Прогон | 262
Прогон | 261
14 x Прогон | 279
3 x Прогон | 278
4 x Прогон | 260
2 x Прогон | 1198
12 x Прогон | 1197
6 x Прогон | 271
36 x Прогон | 270
Прогон | 1694
5 x Прогон | 1693
Прогон | 1692

# IfcBeam: Швеллер22П (751)
In: Undefined
Description: Швеллер22П; Material: STEEL/C245-4
Pset_BeamCommon - LoadBearing: yes
Name | Reference
8 x Балка | 1626
10 x Балка | 1633
262 x Балка | 348
Лестница | 341
2 x Балка | 372
Балка | 374
Балка | 373
14 x Балка | 360
41 x Балка | 387
6 x Балка | 352
12 x Балка | 351
2 x Балка | 371
4 x Балка | 359
2 x Балка | 370
2 x Балка | 358
7 x Балка | 353
3 x Балка | 357
3 x Балка | 356
7 x Балка | 349
Балка | 355
Распорка | 380
4 x Распорка | 381
Распорка | 385
Распорка | 366
Распорка | 383
Распорка | 362
Распорка | 379
5 x Балка | 350
10 x Балка | 1156
14 x Балка | 1168
14 x Балка | 1157
Балка | 1622
10 x Балка | 1167
3 x Балка | 1155
37 x Распорка | 376
21 x Балка | 1158
132 x Балка | 1165
20 x Распорка | 1152
2 x Балка | 1621
4 x Балка | 1631
Балка | 1630
2 x Балка | 1629
Распорка | 1624
5 x Балка | 1627
Распорка | 1623
2 x Балка | 1628
5 x Балка | 1166
4 x Балка | 1160
8 x Балка | 1161
12 x Балка | 1162
2 x Распорка | 1151
Балка | 1164
Балка | 1163
2 x Распорка | 1149
7 x Балка | 1159
2 x Распорка | 375
14 x Балка | 347
6 x Прогон | 340
2 x Прогон | 339
Прогон | 338

# IfcBeam: Швеллер40П (4)
In: Undefined
Description: Швеллер40П; Material: STEEL/C245-4
Pset_BeamCommon - LoadBearing: yes; Reference: 1810

# IfcColumn: ДВУТAВР40Ш1 (162)
In: Undefined
Description: ДВУТAВР40Ш1; Material: STEEL/C255-4
Pset_ColumnCommon - LoadBearing: yes
Name | Reference
2 x Колонна | 307
4 x Колонна | 308
2 x Колонна | 304
24 x Колонна | 305
44 x Колонна | 303
4 x Колонна | 1081
2 x Колонна | 302
72 x Колонна | 306
4 x Колонна | 1577
4 x Колонна | 1080

# IfcColumn: ДВУТAВР60Ш1 (12)
In: Undefined
Description: ДВУТAВР60Ш1; Material: STEEL/C255-4
Pset_ColumnCommon - LoadBearing: yes
Name | Reference
2 x Колонна | 83
4 x Колонна | 82
Колонна | 87
Колонна | 86
Колонна | 85
Колонна | 84
Колонна | 1606
Колонна | 80

# IfcColumn: НС35-1000-0.7 (1252)
In: Undefined
Description: НС35-1000-0.7; Material: STEEL/C235
Pset_ColumnCommon - LoadBearing: yes
Name | Reference
408 x Профлист | 1017
15 x Профлист | 1018
391 x Профлист | 1019
391 x Профлист | 1020
Профлист | 1038
Профлист | 1037
Профлист | 1036
Профлист | 1035
Профлист | 1034
Профлист | 1033
Профлист | 1032
Профлист | 1031
Профлист | 1030
Профлист | 1029
Профлист | 1028
Профлист | 1027
Профлист | 1026
Профлист | 1025
Профлист | 1024
Профлист | 1023
Профлист | 1022
Профлист | 1021
6 x Профлист | 1016
6 x Профлист | 1015
10 x Профлист | 1557
Профлист | 1558
3 x Профлист | 1559
3 x Профлист | 1014

# IfcColumn: Профиль(кв.)100X100X5.0 (72)
In: Undefined
Description: Профиль(кв.)100X100X5.0; Material: STEEL/C245-4
Pset_ColumnCommon - LoadBearing: yes
Name | Reference
5 x Стойка фахверка | 1569
5 x Стойка фахверка | 1570
Стойка фахверка | 863
Стойка фахверка | 862
60 x Стойка фахверка | 860

# IfcColumn: Профиль(кв.)120X120X5.0 (6)
In: Undefined
Description: Профиль(кв.)120X120X5.0; Material: STEEL/C245-4
Pset_ColumnCommon - LoadBearing: yes
Name | Reference
Стремянка | 1809
Стремянка | 1808
4 x Подвес | 1543

# IfcColumn: Профиль(кв.)250X250X6.0 (14)
In: Undefined
Description: Профиль(кв.)250X250X6.0; Material: STEEL/C245-4
Pset_ColumnCommon - LoadBearing: yes
Name | Reference
2 x Стойка | 1230
2 x Стойка | 1229
4 x Стойка | 1228
4 x Стойка | 1227
Стойка | 507
Стойка | 506

# IfcColumn: Уголок100X63X8 (13)
In: Undefined
Description: Уголок100X63X8; Material: STEEL/C245-4
Pset_ColumnCommon - LoadBearing: yes
Name | Reference
4 x Ригель фахверка | 1177
3 x Ригель фахверка | 1181
3 x Ригель фахверка | 1180
Ригель фахверка | 406
Ригель фахверка | 402
Ригель фахверка | 401

# IfcColumn: Уголок63X5 (208)
In: Undefined
Description: Уголок63X5; Material: STEEL/C245-4
Pset_ColumnCommon - LoadBearing: yes
Name | Reference
Стойка фахверка | 1831
2 x Стойка фахверка | 1830
Стойка фахверка | 1829
Стойка фахверка | 1828
Стойка фахверка | 1827
2 x Стойка фахверка | 1826
4 x Стойка фахверка | 942
5 x Стойка фахверка | 940
65 x Стойка фахверка | 937
5 x Стойка фахверка | 939
Стойка фахверка | 941
60 x Стойка фахверка | 938
60 x Стойка фахверка | 935

# IfcDiscreteAccessory: Балка (11932)
In: Undefined
Name | Description | Material
947 x Балка | PL10*145 | STEEL/C245-4
4 x Балка | PL10*217 | STEEL/C245-4
16 x Балка | Круг20 | STEEL/C245-4
4 x Балка | PL25*220 | STEEL/C355-5
28 x Балка | Уголок75X5 | STEEL/C245-4
189 x Балка | Уголок100X63X8 | STEEL/C245-4
97 x Балка | PL10*130 | STEEL/C245-4
247 x Балка | PL10*160 | STEEL/C245-4
1152 x Балка | PL8*180 | STEEL/C245-4
4 x Балка | PL10*220 | STEEL/C245-4
4 x Балка | ДВУТAВР20Ш1 | STEEL/C255-4
2 x Балка | PL6*200 | STEEL/C245-4
141 x Балка | PL10*80 | STEEL/C245-4
942 x Балка | PL10*170 | STEEL/C245-4
1242 x Балка | PL30*350 | STEEL/C255-4
1079 x Балка | PL25*170 | STEEL/C255-4
340 x Балка | PL16*840 | STEEL/C255-4
68 x Балка | PL16*350 | STEEL/C245-4
566 x Балка | PL12*180 | STEEL/C245-4
211 x Балка | PL6*125 | STEEL/C245-4
2 x Балка | Уголок50X5 | STEEL/C245-4
2 x Балка | PL8*230 | STEEL/C245-4
87 x Балка | Уголок125X80X8 | STEEL/C245-4
70 x Балка | PL10*85 | STEEL/C245-4
42 x Балка | Уголок140X90X8 | STEEL/C245-4
195 x Балка | PL10*125 | STEEL/C245-4
153 x Балка | PL8*120 | STEEL/C245-4
20 x Балка | PL10*155 | STEEL/C245-4
5 x Балка | PL12*120 | STEEL/C245-4
116 x Балка | PL10*70 | STEEL/C245-4
716 x Балка | PL6*60 | STEEL/C245-4
2 x Балка | PL10*285 | STEEL/C245-4
Балка | PL10*275 | STEEL/C245-4
6 x Балка | PL8*160 | STEEL/C245-4
29 x Балка | PL10*250 | STEEL/C245-4
53 x Балка | PL10*245 | STEEL/C245-4
Балка | PL10*280 | STEEL/C245-4
5 x Балка | PL10*300 | STEEL/C245-4
20 x Балка | PL10*205 | STEEL/C245-4
Балка | PL10*213 | STEEL/C245-4
144 x Балка | PL10*255 | STEEL/C245-4
5 x Балка | PL10*260 | STEEL/C245-4
2 x Балка | PL10*265 | STEEL/C245-4
Балка | PL10*340 | STEEL/C245-4
Балка | PL10*365 | STEEL/C245-4
6 x Балка | PL10*270 | STEEL/C245-4
3 x Балка | PL10*325 | STEEL/C245-4
3 x Балка | PL10*315 | STEEL/C245-4
9 x Балка | Швеллер22П | STEEL/C245-4
54 x Балка | PL10*115 | STEEL/C245-4
11 x Балка | PL10*95 | STEEL/C245-4
6 x Балка | PL8*150 | STEEL/C245-4
16 x Балка | PL12*145 | STEEL/C245-4
59 x Балка | PL16*145 | STEEL/C245-4
12 x Балка | PL10*258 | STEEL/C245-4
26 x Балка | PL8*250 | STEEL/C245-4
28 x Балка | PL25*145 | STEEL/C255-4
Балка | PL10*263 | STEEL/C245-4
9 x Балка | ДВУТAВР30Ш1 | STEEL/C255-4
150 x Балка | PL8*175 | STEEL/C245-4
162 x Балка | PL8*170 | STEEL/C245-4
362 x Балка | PL16*170 | STEEL/C245-4
32 x Балка | PL8*200 | STEEL/C245-4
28 x Балка | PL8*420 | STEEL/C245-4
32 x Балка | PL12*400 | STEEL/C245-4
8 x Балка | PL25*420 | STEEL/C255-4
24 x Балка | PL16*420 | STEEL/C245-4
4 x Балка | PL30*420 | STEEL/C255-4
12 x Балка | PL10*180 | STEEL/C245-4
13 x Балка | PL10*400 | STEEL/C245-4
22 x Балка | PL12*170 | STEEL/C245-4
71 x Балка | PL10*390 | STEEL/C245-4
10 x Балка | PL12*235 | STEEL/C245-4
128 x Балка | PL10*235 | STEEL/C245-4
2 x Балка | PL10*310 | STEEL/C245-4
198 x Балка | PL6*80 | STEEL/C245-4
10 x Балка | PL10*470 | STEEL/C245-4
10 x Балка | PL10*290 | STEEL/C245-4
10 x Балка | PL10*165 | STEEL/C245-4
40 x Балка | PL16*120 | STEEL/C245-4
10 x Балка | PL20*120 | STEEL/C255-4
5 x Балка | PL16*680 | STEEL/C245-4
5 x Балка | PL20*250 | STEEL/C255-4
5 x Балка | PL20*80 | STEEL/C255-4
816 x Балка | PL8*165 | STEEL/C245-4
68 x Балка | PL8*220 | STEEL/C245-4
68 x Балка | PL12*384 | STEEL/C245-4
68 x Балка | PL12*375 | STEEL/C245-4
68 x Балка | PL16*587 | STEEL/C255-4
68 x Балка | PL16*962 | STEEL/C255-4
68 x Балка | PL12*200 | STEEL/C245-4
132 x Балка | PL30*170 | STEEL/C255-4
12 x Балка | PL22*300 | STEEL/C255-4
6 x Балка | ДВУТAВР60Ш1 | STEEL/C255-4

# IfcDiscreteAccessory: Закладная деталь (1137)
In: Undefined
Name | Description | Material
1072 x Закладная деталь | Круг16 | STEEL/C245-4
64 x Закладная деталь | Круг20 | STEEL/C245-4
Закладная деталь | PL25*170 | STEEL/C255-4

# IfcDiscreteAccessory: Колонна (4971)
In: Undefined
Name | Description | Material
4 x Колонна | Швеллер22П | STEEL/C245-4
336 x Колонна | PL10*140 | STEEL/C245-4
76 x Колонна | PL8*195 | STEEL/C245-4
10 x Колонна | PL12*445 | STEEL/C245-4
228 x Колонна | PL12*195 | STEEL/C245-4
4 x Колонна | PL25*120 | STEEL/C255-4
4 x Колонна | PL30*275 | STEEL/C355-5
16 x Колонна | PL12*250 | STEEL/C245-4
16 x Колонна | PL10*400 | STEEL/C245-4
326 x Колонна | Уголок125X80X8 | STEEL/C245-4
44 x Колонна | Уголок100X63X8 | STEEL/C245-4
20 x Колонна | PL8*230 | STEEL/C245-4
2 x Колонна | ДВУТAВР40Ш1 | STEEL/C255-4
4 x Колонна | PL10*360 | STEEL/C245-4
22 x Колонна | PL10*268 | STEEL/C245-4
196 x Колонна | PL8*95 | STEEL/C245-4
10 x Колонна | PL8*350 | STEEL/C245-4
10 x Колонна | PL8*295 | STEEL/C245-4
6 x Колонна | PL8*245 | STEEL/C245-4
6 x Колонна | PL8*430 | STEEL/C245-4
4 x Колонна | PL8*250 | STEEL/C245-4
4 x Колонна | PL8*435 | STEEL/C245-4
25 x Колонна | PL12*125 | STEEL/C245-4
400 x Колонна | PL10*235 | STEEL/C245-4
8 x Колонна | PL10*200 | STEEL/C245-4
48 x Колонна | PL10*225 | STEEL/C245-4
188 x Колонна | PL12*145 | STEEL/C245-4
256 x Колонна | PL10*265 | STEEL/C245-4
24 x Колонна | PL4*130 | STEEL/C235
8 x Колонна | PL4*128 | STEEL/C235
24 x Колонна | Профиль(кв.)140X140X5.0 | STEEL/C245-4
2 x Колонна | PL10*245 | STEEL/C245-4
4 x Колонна | PL10*170 | STEEL/C245-4
640 x Колонна | Уголок100X7 | STEEL/C245-4
298 x Колонна | PL10*100 | STEEL/C245-4
140 x Колонна | PL8*150 | STEEL/C245-4
138 x Колонна | PL8*140 | STEEL/C245-4
10 x Колонна | Уголок75X6 | STEEL/C245-4
10 x Колонна | PL10*60 | STEEL/C245-4
10 x Колонна | PL12*190 | STEEL/C245-4
20 x Колонна | PL12*150 | STEEL/C245-4
10 x Колонна | PL16*390 | STEEL/C245-4
160 x Колонна | PL6*80 | STEEL/C245-4
68 x Колонна | PL12*115 | STEEL/C245-4
68 x Колонна | PL16*300 | STEEL/C245-4
68 x Колонна | PL12*200 | STEEL/C245-4
136 x Колонна | PL16*840 | STEEL/C255-4
272 x Колонна | PL30*350 | STEEL/C255-4
118 x Колонна | PL40*250 | STEEL/C355-5
12 x Колонна | Уголок140X90X8 | STEEL/C245-4
12 x Колонна | PL40*270 | STEEL/C355-5
24 x Колонна | PL16*145 | STEEL/C245-4
12 x Колонна | PL20*300 | STEEL/C255-4
12 x Колонна | PL25*300 | STEEL/C255-4
164 x Колонна | PL10*65 | STEEL/C245-4
76 x Колонна | PL30*300 | STEEL/C355-5
82 x Колонна | PL40*400 | STEEL/C355-5
74 x Колонна | PL12*140 | STEEL/C245-4
2 x Колонна | PL30*340 | STEEL/C355-5

# IfcDiscreteAccessory: Кронштейн (110)
In: Undefined
Material: STEEL/C245-4
Name | Description
22 x Кронштейн | PL8*230
44 x Кронштейн | PL8*120
44 x Кронштейн | PL8*150

# IfcDiscreteAccessory: Лестница (4468)
In: Undefined
Name | Description | Material
2363 x Лестница | Уголок63X5 | STEEL/C245-4
106 x Лестница | PL6*125 | STEEL/C245-4
214 x Лестница | Уголок100X63X8 | STEEL/C245-4
71 x Лестница | Швеллер20П | STEEL/C245-4
744 x Лестница | ПВ13*200 | MISCELLANEOUS/ПВ506
372 x Лестница | PL6*130 | STEEL/C245-4
14 x Лестница | Уголок125X80X8 | STEEL/C245-4
207 x Лестница | Швеллер16П | STEEL/C245-4
4 x Лестница | PL6*60 | STEEL/C245-4
26 x Лестница | PL12*120 | STEEL/C245-4
97 x Лестница | Риф4*700 | MISCELLANEOUS/Риф4
60 x Лестница | PL10*160 | STEEL/C245-4
180 x Лестница | PL6*115 | STEEL/C245-4
Лестница | ПВ13*980 | MISCELLANEOUS/ПВ506
5 x Лестница | Швеллер22П | STEEL/C245-4
2 x Лестница | ПВ13*180 | MISCELLANEOUS/ПВ506
2 x Лестница | PL10*155 | STEEL/C245-4

# IfcDiscreteAccessory: Монтажный элемент (4)
In: Undefined
Name | Description | Material
2 x Монтажный элемент | PL6*60 | STEEL/C245-4
2 x Монтажный элемент | PL30*480 | STEEL/C255-4

# IfcDiscreteAccessory: Настил (5406)
In: Undefined
Name | Description | Material
5206 x Настил | PL4*60 | STEEL/C235
10 x Настил | Уголок50X5 | STEEL/C245-4
179 x Настил | Уголок35X4 | STEEL/C245-4
Настил | Риф5*320 | MISCELLANEOUS/Риф5
2 x Настил | Риф5*490 | MISCELLANEOUS/Риф5
Настил | Риф5*390 | MISCELLANEOUS/Риф5
6 x Настил | Риф5*782 | MISCELLANEOUS/Риф5
Настил | Риф5*770 | MISCELLANEOUS/Риф5

# IfcDiscreteAccessory: Ограждение (7905)
In: Undefined
Name | Description | Material
682 x Ограждение | PL4*18 | STEEL/C235
1591 x Ограждение | PL4*38 | STEEL/C235
195 x Ограждение | PL6*60 | STEEL/C245-4
1339 x Ограждение | Труба21.3x2.5 | STEEL/C235
1066 x Ограждение | Труба42.3x2.8 | STEEL/C235
225 x Ограждение | PL4*140 | STEEL/C235
869 x Ограждение | PL6*100 | STEEL/C245-4
1386 x Ограждение | Круг16 | STEEL/C245-4
552 x Ограждение | Уголок63X5 | STEEL/C245-4

# IfcDiscreteAccessory: Петля (240)
In: Undefined
Name | Description | Material
120 x Петля | Труба21.3x2.5 | STEEL/C235
120 x Петля | Круг16 | STEEL/C245-4

# IfcDiscreteAccessory: Площадка (13)
In: Undefined
Description: PL4*140; Material: STEEL/C235

# IfcDiscreteAccessory: Подвес (28)
In: Undefined
Name | Description | Material
4 x Подвес | PL4*110 | STEEL/C235
4 x Подвес | Уголок100X63X8 | STEEL/C245-4
8 x Подвес | PL4*65 | STEEL/C235
8 x Подвес | PL4*40 | STEEL/C235
4 x Подвес | PL10*260 | STEEL/C245-4

# IfcDiscreteAccessory: Прогон (980)
In: Undefined
Material: STEEL/C245-4
Name | Description
28 x Прогон | Уголок100X63X8
848 x Прогон | PL8*170
104 x Прогон | PL8*205

# IfcDiscreteAccessory: Распорка (7911)
In: Undefined
Name | Description | Material
105 x Распорка | PL8*100 | STEEL/C245-4
720 x Распорка | PL4*40 | STEEL/C235
8 x Распорка | PL12*430 | STEEL/C245-4
140 x Распорка | PL8*110 | STEEL/C245-4
140 x Распорка | PL8*90 | STEEL/C245-4
140 x Распорка | PL10*220 | STEEL/C245-4
4 x Распорка | PL12*785 | STEEL/C245-4
92 x Распорка | PL8*170 | STEEL/C245-4
92 x Распорка | PL8*150 | STEEL/C245-4
82 x Распорка | PL12*240 | STEEL/C245-4
14 x Распорка | PL4*130 | STEEL/C235
2 x Распорка | PL4*5795 | STEEL/C235
1438 x Распорка | Уголок50X5 | STEEL/C245-4
2 x Распорка | PL10*360 | STEEL/C245-4
3 x Распорка | PL10*350 | STEEL/C245-4
79 x Распорка | Швеллер22П | STEEL/C245-4
10 x Распорка | PL10*115 | STEEL/C245-4
466 x Распорка | Уголок125X80X8 | STEEL/C245-4
1292 x Распорка | PL4*170 | STEEL/C235
2 x Распорка | PL4*920 | STEEL/C235
6 x Распорка | PL4*1160 | STEEL/C235
39 x Распорка | PL4*5980 | STEEL/C235
Распорка | PL4*3660 | STEEL/C235
20 x Распорка | PL4*5740 | STEEL/C235
138 x Распорка | PL4*150 | STEEL/C235
2 x Распорка | PL4*5680 | STEEL/C235
Распорка | PL4*5820 | STEEL/C235
122 x Распорка | PL4*148 | STEEL/C235
1268 x Распорка | PL6*75 | STEEL/C245-4
130 x Распорка | PL4*80 | STEEL/C235
130 x Распорка | PL4*110 | STEEL/C235
138 x Распорка | PL10*95 | STEEL/C245-4
138 x Распорка | Уголок100X63X8 | STEEL/C245-4
130 x Распорка | Уголок125X8 | STEEL/C245-4
65 x Распорка | Труба89X5.5 | STEEL/C245-4
65 x Распорка | Уголок140X90X8 | STEEL/C245-4
600 x Распорка | PL8*80 | STEEL/C245-4
10 x Распорка | PL10*240 | STEEL/C245-4
5 x Распорка | PL12*820 | STEEL/C245-4
10 x Распорка | PL8*175 | STEEL/C245-4
10 x Распорка | PL8*145 | STEEL/C245-4
10 x Распорка | PL16*240 | STEEL/C245-4
5 x Распорка | PL12*550 | STEEL/C245-4
36 x Распорка | PL12*800 | STEEL/C245-4
Распорка | PL12*850 | STEEL/C245-4

# IfcDiscreteAccessory: Ригель фахверка (1056)
In: Undefined
Name | Description | Material
12 x Ригель фахверка | Уголок100X63X8 | STEEL/C245-4
956 x Ригель фахверка | PL4*128 | STEEL/C235
72 x Ригель фахверка | PL4*88 | STEEL/C235
8 x Ригель фахверка | Уголок125X80X8 | STEEL/C245-4
8 x Ригель фахверка | PL4*130 | STEEL/C235

# IfcDiscreteAccessory: Связь (2766)
In: Undefined
Name | Description | Material
248 x Связь | PL8*120 | STEEL/C245-4
208 x Связь | PL8*150 | STEEL/C245-4
114 x Связь | PL8*90 | STEEL/C245-4
892 x Связь | PL4*40 | STEEL/C235
3 x Связь | PL12*316 | STEEL/C245-4
Связь | PL12*307 | STEEL/C245-4
Связь | PL12*402 | STEEL/C245-4
Связь | PL12*266 | STEEL/C245-4
Связь | PL12*326 | STEEL/C245-4
Связь | PL12*317 | STEEL/C245-4
10 x Связь | PL8*95 | STEEL/C245-4
10 x Связь | PL8*85 | STEEL/C245-4
4 x Связь | PL12*296 | STEEL/C245-4
4 x Связь | PL12*304 | STEEL/C245-4
4 x Связь | PL12*278 | STEEL/C245-4
4 x Связь | PL12*322 | STEEL/C245-4
8 x Связь | PL12*292 | STEEL/C245-4
4 x Связь | PL12*300 | STEEL/C245-4
4 x Связь | PL12*272 | STEEL/C245-4
4 x Связь | PL12*318 | STEEL/C245-4
10 x Связь | PL12*291 | STEEL/C245-4
2 x Связь | PL12*299 | STEEL/C245-4
2 x Связь | PL12*270 | STEEL/C245-4
40 x Связь | PL8*190 | STEEL/C245-4
756 x Связь | PL8*100 | STEEL/C245-4
192 x Связь | PL12*220 | STEEL/C245-4
12 x Связь | PL12*280 | STEEL/C245-4
6 x Связь | PL12*277 | STEEL/C245-4
40 x Связь | PL8*135 | STEEL/C245-4
20 x Связь | PL16*290 | STEEL/C245-4
2 x Связь | PL12*285 | STEEL/C245-4
2 x Связь | PL12*301 | STEEL/C245-4
6 x Связь | PL12*281 | STEEL/C245-4
72 x Связь | PL12*290 | STEEL/C245-4
72 x Связь | PL12*294 | STEEL/C245-4
2 x Связь | PL8*110 | STEEL/C245-4
2 x Связь | PL12*543 | STEEL/C245-4
2 x Связь | PL12*250 | STEEL/C245-4

# IfcDiscreteAccessory: Стойка (68)
In: Undefined
Name | Description | Material
42 x Стойка | Уголок100X63X8 | STEEL/C245-4
14 x Стойка | PL10*238 | STEEL/C245-4
12 x Стойка | PL30*480 | STEEL/C255-4

# IfcDiscreteAccessory: Стойка фахверка (185)
In: Undefined
Name | Description | Material
125 x Стойка фахверка | PL4*88 | STEEL/C235
5 x Стойка фахверка | Профиль(кв.)100X100X5.0 | STEEL/C245-4
Стойка фахверка | PL6*130 | STEEL/C245-4
12 x Стойка фахверка | PL4*130 | STEEL/C235
17 x Стойка фахверка | Уголок125X80X8 | STEEL/C245-4
Стойка фахверка | PL10*155 | STEEL/C245-4
24 x Стойка фахверка | PL12*120 | STEEL/C245-4

# IfcDiscreteAccessory: Стремянка (73)
In: Undefined
Name | Description | Material
29 x Стремянка | PL4*40 | STEEL/C235
34 x Стремянка | Круг20 | STEEL/C245-4
4 x Стремянка | PL4*110 | STEEL/C235
4 x Стремянка | PL10*140 | STEEL/C245-4
2 x Стремянка | Профиль(кв.)120X120X5.0 | STEEL/C245-4

# IfcDiscreteAccessory: Ферма (1416)
In: Undefined
Name | Description | Material
59 x Ферма | PL30*300 | STEEL/C355-5
236 x Ферма | PL12*75 | STEEL/C245-4
59 x Ферма | PL12*140 | STEEL/C245-4
59 x Ферма | PL12*200 | STEEL/C245-4
59 x Ферма | PL10*240 | STEEL/C245-4
236 x Ферма | PL10*120 | STEEL/C245-4
118 x Ферма | PL12*170 | STEEL/C245-4
177 x Ферма | ДВУТAВР20К1 | STEEL/C255-4
59 x Ферма | PL10*200 | STEEL/C245-4
236 x Ферма | PL12*120 | STEEL/C245-4
118 x Ферма | PL16*250 | STEEL/C245-4

# IfcDiscreteAccessory: Щит (596)
In: Undefined
Name | Description | Material
128 x Щит | Круг16 | STEEL/C245-4
128 x Щит | PL6*100 | STEEL/C245-4
8 x Щит | PL6*80 | STEEL/C245-4
88 x Щит | PL4*50 | STEEL/C235
4 x Щит | Риф4*431 | MISCELLANEOUS/Риф4
120 x Щит | PL6*50 | STEEL/C245-4
120 x Щит | Труба21.3x2.5 | STEEL/C235

# IfcElementAssembly (11390)
In: Undefined
Name | PredefinedType | ASSEMBLY_POS
Steel Assembly | RIGID_FRAME | Б8-1
48 x Steel Assembly | RIGID_FRAME | 4ЗД5-1
8 x Steel Assembly | RIGID_FRAME | 4ЗД3-1
40 x Steel Assembly | RIGID_FRAME | 4ЗД2-1
66 x Steel Assembly | RIGID_FRAME | 4ЗД1-1
Steel Assembly |  | 4Н1-133
3 x Steel Assembly |  | 4Н1-127
2 x Steel Assembly |  | 4Н1-132
Steel Assembly |  | 4Н1-131
Steel Assembly |  | 4Н1-130
2 x Steel Assembly |  | 4Н1-129
Steel Assembly |  | 4Н1-126
Steel Assembly |  | 4Н1-128
2 x Steel Assembly |  | 4Н1-124
2 x Steel Assembly |  | 4Н1-125
2 x Steel Assembly |  | 4Н1-105
2 x Steel Assembly |  | 4Н1-106
Steel Assembly |  | 4Н1-119
Steel Assembly |  | 4Н1-120
Steel Assembly |  | 4Н1-121
Steel Assembly |  | 4Н1-122
Steel Assembly |  | 4Н1-118
Steel Assembly |  | 4Н1-117
Steel Assembly |  | 4Н1-115
Steel Assembly |  | 4Н1-116
Steel Assembly | RIGID_FRAME | 4Б6-2
Steel Assembly | RIGID_FRAME | 4Б6-1
Steel Assembly | RIGID_FRAME | 4Б6-4
Steel Assembly | RIGID_FRAME | 4Б6-3
40 x Steel Assembly | RIGID_FRAME | 4ЗД2-2
Steel Assembly | RIGID_FRAME | 4СФ3-7
2 x Steel Assembly | RIGID_FRAME | 4СФ3-9
Steel Assembly | RIGID_FRAME | 4СФ3-8
77 x Steel Assembly | RIGID_FRAME | 4Н3-1
Steel Assembly | RIGID_FRAME | 4СФ1-2
Steel Assembly | RIGID_FRAME | 4Н3-9
Steel Assembly | RIGID_FRAME | 3СФ1-1
Steel Assembly | RIGID_FRAME | 4СФ1-1
Steel Assembly | RIGID_FRAME | 3СФ1-2
2 x Steel Assembly | RIGID_FRAME | 4ОГ1-23
2 x Steel Assembly | RIGID_FRAME | 4ОГ1-25
Steel Assembly | RIGID_FRAME | 4ОГ1-27
Steel Assembly | RIGID_FRAME | 4ОГ1-28
Steel Assembly | RIGID_FRAME | 4ОГ1-24
Steel Assembly | RIGID_FRAME | 4Л5-2
Steel Assembly | RIGID_FRAME | 4Л5-1
Steel Assembly |  | 4Н1-110
2 x Steel Assembly |  | 4Н1-114
8 x Steel Assembly |  | 4Н1-104
8 x Steel Assembly |  | 4Н1-107
2 x Steel Assembly |  | 4Н1-113
2 x Steel Assembly |  | 4Н1-111
4 x Steel Assembly | RIGID_FRAME | 4Б13-12
4 x Steel Assembly | RIGID_FRAME | 4Б13-11
4 x Steel Assembly | RIGID_FRAME | 4Б13-16
24 x Steel Assembly | RIGID_FRAME | 4Б13-8
3 x Steel Assembly | RIGID_FRAME | 4Б13-14
4 x Steel Assembly | RIGID_FRAME | 4Б13-15
4 x Steel Assembly | RIGID_FRAME | 4Б7-29
4 x Steel Assembly | RIGID_FRAME | 4Б7-37
4 x Steel Assembly | RIGID_FRAME | 4Б7-32
4 x Steel Assembly | RIGID_FRAME | 4Б7-33
2 x Steel Assembly | RIGID_FRAME | 4Б7-31
2 x Steel Assembly | RIGID_FRAME | 4Б10-2
2 x Steel Assembly | RIGID_FRAME | 4Б10-1
4 x Steel Assembly | RIGID_FRAME | 4ОГ1-21
2 x Steel Assembly | RIGID_FRAME | 4ОГ1-26
12 x Steel Assembly | RIGID_FRAME | 4ОГ1-20
4 x Steel Assembly |  | 4Щ2-1
4 x Steel Assembly |  | 4Н1-112
Steel Assembly |  | 4Н1-123
Steel Assembly |  | 4Н1-108
Steel Assembly |  | 4Н1-109
Steel Assembly | RIGID_FRAME | 4ОГ1-22
Steel Assembly | RIGID_FRAME | 4Б13-17
Steel Assembly | RIGID_FRAME | 4Б13-19
2 x Steel Assembly | RIGID_FRAME | 4Б13-9
2 x Steel Assembly | RIGID_FRAME | 4Б13-18
Steel Assembly | RIGID_FRAME | 4Б13-13
Steel Assembly | RIGID_FRAME | 4Б13-10
Steel Assembly | RIGID_FRAME | 4Б15-1
Steel Assembly | RIGID_FRAME | 4К1-20
Steel Assembly | RIGID_FRAME | 4К1-18
4 x Steel Assembly | RIGID_FRAME | 4СВ5-3
Steel Assembly | RIGID_FRAME | 4РС3-2
Steel Assembly | RIGID_FRAME | 4РС6-3
Steel Assembly | RIGID_FRAME | 4К1-16
Steel Assembly | RIGID_FRAME | 4К1-14
25 x Steel Assembly |  | 2Н1-13
Steel Assembly | RIGID_FRAME | 4Б5-2
Steel Assembly | RIGID_FRAME | 4Б7-9
Steel Assembly | RIGID_FRAME | 4Б7-20
Steel Assembly | RIGID_FRAME | 4Б7-13
Steel Assembly | RIGID_FRAME | 4Б7-14
Steel Assembly | RIGID_FRAME | 4Б11-1
Steel Assembly | RIGID_FRAME | 4Б2-1
Steel Assembly | RIGID_FRAME | 4Б4-22
Steel Assembly | RIGID_FRAME | 4К1-10
Steel Assembly | RIGID_FRAME | 3Б7-10
Steel Assembly | RIGID_FRAME | 3Б7-20
Steel Assembly | RIGID_FRAME | 3Б7-14
Steel Assembly | RIGID_FRAME | 3Б7-15
Steel Assembly | RIGID_FRAME | 3Б11-1
Steel Assembly | RIGID_FRAME | 3Б2-1
Steel Assembly | RIGID_FRAME | 3Б4-21
Steel Assembly | RIGID_FRAME | 3Б4-25
Steel Assembly | RIGID_FRAME | 3К1-12
Steel Assembly | RIGID_FRAME | 2Б11-2
2 x Steel Assembly | RIGID_FRAME | 2Б7-11
2 x Steel Assembly | RIGID_FRAME | 2Б7-20
2 x Steel Assembly | RIGID_FRAME | 2Б7-16
2 x Steel Assembly | RIGID_FRAME | 2Б7-17
2 x Steel Assembly | RIGID_FRAME | 2Б4-18
2 x Steel Assembly | RIGID_FRAME | 2Б4-22
Steel Assembly | RIGID_FRAME | 2Б2-3
2 x Steel Assembly | RIGID_FRAME | 2К1-12
Steel Assembly | RIGID_FRAME | 2Б2-1
Steel Assembly | RIGID_FRAME | 3Б13-8
Steel Assembly | RIGID_FRAME | 3ОГ1-11
4 x Steel Assembly | RIGID_FRAME | 3ОГ1-6
4 x Steel Assembly | RIGID_FRAME | 3ОГ1-7
4 x Steel Assembly | RIGID_FRAME | 3ОГ1-4
4 x Steel Assembly | RIGID_FRAME | 3ОГ3-3
4 x Steel Assembly | RIGID_FRAME | 3ОГ3-4
Steel Assembly | RIGID_FRAME | 3КР1-1
2 x Steel Assembly | RIGID_FRAME | 3Б13-2
Steel Assembly | RIGID_FRAME | 3ОГ3-1
Steel Assembly | RIGID_FRAME | 3ОГ3-2
3 x Steel Assembly | RIGID_FRAME | 3Б13-1
Steel Assembly | RIGID_FRAME | 3Л3-2
Steel Assembly | RIGID_FRAME | 3КР1-2
2 x Steel Assembly | RIGID_FRAME | 3Л3-1
Steel Assembly | RIGID_FRAME | 3Б13-7
2 x Steel Assembly | RIGID_FRAME | 3РФ1-9
Steel Assembly | RIGID_FRAME | 3Л3-3
Steel Assembly | RIGID_FRAME | 3Л3-4
Steel Assembly | RIGID_FRAME | 3Б5-1
Steel Assembly | RIGID_FRAME | 3Б13-5
Steel Assembly | RIGID_FRAME | 3РС2-2
Steel Assembly | RIGID_FRAME | 3ОГ1-5
Steel Assembly | RIGID_FRAME | 3ОГ1-1
Steel Assembly | RIGID_FRAME | 3Л1-2
Steel Assembly | RIGID_FRAME | 3ОГ1-8
Steel Assembly | RIGID_FRAME | 3ОГ2-2
Steel Assembly | RIGID_FRAME | 3ОГ2-4
3 x Steel Assembly | RIGID_FRAME | 3Б13-3
6 x Steel Assembly | RIGID_FRAME | 3ОГ1-3
2 x Steel Assembly | RIGID_FRAME | 3Л1-1
3 x Steel Assembly | RIGID_FRAME | 3Б13-4
Steel Assembly | RIGID_FRAME | 3Л1-3
3 x Steel Assembly | RIGID_FRAME | 3ОГ1-9
Steel Assembly | RIGID_FRAME | 3ОГ2-6
Steel Assembly | RIGID_FRAME | 3ОГ2-5
6 x Steel Assembly | RIGID_FRAME | 3ОГ1-2
4 x Steel Assembly | RIGID_FRAME | 3ОГ2-1
4 x Steel Assembly | RIGID_FRAME | 3ОГ2-3
16 x Steel Assembly | RIGID_FRAME | 3Ш-2
Steel Assembly | RIGID_FRAME | 3СТ1-2
Steel Assembly | RIGID_FRAME | 3СТ1-1
Steel Assembly | RIGID_FRAME | 3Б13-6
Steel Assembly | RIGID_FRAME | 3Б-1
Steel Assembly | RIGID_FRAME | 3ОГ1-12
Steel Assembly | RIGID_FRAME | 3Б8-3
2 x Steel Assembly | RIGID_FRAME | 3РФ1-10
Steel Assembly | RIGID_FRAME | 3К2-4
Steel Assembly | RIGID_FRAME | 3К2-3
4 x Steel Assembly | RIGID_FRAME | 3ОГ1-10
Steel Assembly | RIGID_FRAME | 3К1-5
Steel Assembly | RIGID_FRAME | 3К1-8
Steel Assembly |  | 3Н4-10
4 x Steel Assembly | RIGID_FRAME | 3ОГ5-2
4 x Steel Assembly |  | 3Н4-7
4 x Steel Assembly |  | 3Н4-6
4 x Steel Assembly |  | 3Н4-5
Steel Assembly |  | 3Н4-1
2 x Steel Assembly |  | 3Н4-2
3 x Steel Assembly |  | 3Н4-4
4 x Steel Assembly |  | 3Н4-8
2 x Steel Assembly |  | 3Н4-9
3 x Steel Assembly |  | 3Н4-3
Steel Assembly | RIGID_FRAME | 2Б-1
Steel Assembly |  | 2Н4-10
Steel Assembly | RIGID_FRAME | 2Л3-2
4 x Steel Assembly | RIGID_FRAME | 2ОГ5-2
Steel Assembly | RIGID_FRAME | 2ОГ1-12
Steel Assembly | RIGID_FRAME | 2ОГ1-11
Steel Assembly | RIGID_FRAME | 2Б13-8
4 x Steel Assembly | RIGID_FRAME | 2ОГ1-6
4 x Steel Assembly | RIGID_FRAME | 2ОГ1-7
4 x Steel Assembly | RIGID_FRAME | 2ОГ1-4
3 x Steel Assembly | RIGID_FRAME | 2Б13-1
2 x Steel Assembly | RIGID_FRAME | 2Л3-1
4 x Steel Assembly |  | 2Н4-7
4 x Steel Assembly |  | 2Н4-6
4 x Steel Assembly |  | 2Н4-5
Steel Assembly | RIGID_FRAME | 2Л3-3
Steel Assembly | RIGID_FRAME | 2Л3-4
4 x Steel Assembly | RIGID_FRAME | 2ОГ3-3
4 x Steel Assembly | RIGID_FRAME | 2ОГ3-4
Steel Assembly | RIGID_FRAME | 2Б8-3
Steel Assembly | RIGID_FRAME | 2КР1-1
Steel Assembly | RIGID_FRAME | 2КР1-2
2 x Steel Assembly | RIGID_FRAME | 2Б13-2
2 x Steel Assembly | RIGID_FRAME | 2РФ1-9
2 x Steel Assembly | RIGID_FRAME | 2РФ1-10
Steel Assembly | RIGID_FRAME | 2Б13-5
Steel Assembly | RIGID_FRAME | 2РС2-2
Steel Assembly | RIGID_FRAME | 2Б13-7
Steel Assembly |  | 2Н4-1
2 x Steel Assembly |  | 2Н4-2
Steel Assembly | RIGID_FRAME | 2ОГ1-5
Steel Assembly | RIGID_FRAME | 2Л1-2
Steel Assembly | RIGID_FRAME | 2К2-4
Steel Assembly | RIGID_FRAME | 2К2-3
Steel Assembly | RIGID_FRAME | 2ОГ3-1
Steel Assembly | RIGID_FRAME | 2ОГ3-2
Steel Assembly | RIGID_FRAME | 2ОГ1-1
Steel Assembly | RIGID_FRAME | 2ОГ1-8
Steel Assembly | RIGID_FRAME | 2ОГ2-2
Steel Assembly | RIGID_FRAME | 2ОГ2-4
3 x Steel Assembly | RIGID_FRAME | 2Б13-3
9 x Steel Assembly | RIGID_FRAME | 2ОГ1-3
2 x Steel Assembly | RIGID_FRAME | 2Л1-1
3 x Steel Assembly | RIGID_FRAME | 2Б13-4
Steel Assembly | RIGID_FRAME | 2Л1-3
3 x Steel Assembly | RIGID_FRAME | 2ОГ1-9
Steel Assembly | RIGID_FRAME | 2ОГ2-6
Steel Assembly | RIGID_FRAME | 2ОГ2-5
9 x Steel Assembly | RIGID_FRAME | 2ОГ1-2
6 x Steel Assembly | RIGID_FRAME | 2ОГ2-1
6 x Steel Assembly | RIGID_FRAME | 2ОГ2-3
24 x Steel Assembly | RIGID_FRAME | 2Ш-2
Steel Assembly | RIGID_FRAME | 2СТ1-2
Steel Assembly | RIGID_FRAME | 2СТ1-1
6 x Steel Assembly | RIGID_FRAME | 2ОГ1-10
3 x Steel Assembly |  | 2Н4-4
6 x Steel Assembly |  | 2Н4-8
3 x Steel Assembly |  | 2Н4-9
3 x Steel Assembly |  | 2Н4-3
Steel Assembly | RIGID_FRAME | 2Б13-6
Steel Assembly | RIGID_FRAME | 2Б5-1
Steel Assembly | RIGID_FRAME | 2К1-5
Steel Assembly | RIGID_FRAME | 2К1-8
Steel Assembly | RIGID_FRAME | 1РФ1-11
74 x Steel Assembly | RIGID_FRAME | 4Н3-2
74 x Steel Assembly | RIGID_FRAME | 4Н3-3
84 x Steel Assembly | RIGID_FRAME | 3Н3-2
84 x Steel Assembly | RIGID_FRAME | 3Н3-3
173 x Steel Assembly | RIGID_FRAME | 2Н3-1
173 x Steel Assembly | RIGID_FRAME | 2Н3-2
60 x Steel Assembly | RIGID_FRAME | 1Н3-7
60 x Steel Assembly | RIGID_FRAME | 1Н3-8
84 x Steel Assembly | RIGID_FRAME | 3Н3-1
172 x Steel Assembly | RIGID_FRAME | 2Н3-3
75 x Steel Assembly | RIGID_FRAME | 1Н3-1
14 x Steel Assembly | RIGID_FRAME | 1Н3-2
Steel Assembly | RIGID_FRAME | 1Н3-26
Steel Assembly | RIGID_FRAME | 1Н3-25
Steel Assembly | RIGID_FRAME | 1Н3-24
Steel Assembly | RIGID_FRAME | 1Н3-23
Steel Assembly | RIGID_FRAME | 1Н3-22
Steel Assembly | RIGID_FRAME | 1Н3-21
Steel Assembly | RIGID_FRAME | 1Н3-20
Steel Assembly | RIGID_FRAME | 1Н3-19
Steel Assembly | RIGID_FRAME | 1Н3-18
Steel Assembly | RIGID_FRAME | 1Н3-17
Steel Assembly | RIGID_FRAME | 1Н3-16
Steel Assembly | RIGID_FRAME | 1Н3-15
Steel Assembly | RIGID_FRAME | 1Н3-14
Steel Assembly | RIGID_FRAME | 1Н3-13
Steel Assembly | RIGID_FRAME | 1Н3-12
Steel Assembly | RIGID_FRAME | 1Н3-11
Steel Assembly | RIGID_FRAME | 1Н3-10
Steel Assembly | RIGID_FRAME | 1Н3-9
Steel Assembly | RIGID_FRAME | 1ОГ1-1
3 x Steel Assembly | RIGID_FRAME | 2В-4
Steel Assembly | RIGID_FRAME | 2ОГ1-20
6 x Steel Assembly | RIGID_FRAME | 2Н3-4
6 x Steel Assembly | RIGID_FRAME | 2Н3-5
9 x Steel Assembly | RIGID_FRAME | 2Н3-6
15 x Steel Assembly | RIGID_FRAME | 2РФ2-1
3 x Steel Assembly | RIGID_FRAME | 2СФ2-2
3 x Steel Assembly | RIGID_FRAME | 2Н3-8
Steel Assembly | RIGID_FRAME | 2В-2
Steel Assembly | RIGID_FRAME | 2В-1
3 x Steel Assembly | RIGID_FRAME | 2В-3
3 x Steel Assembly | RIGID_FRAME | 2СФ2-3
3 x Steel Assembly | RIGID_FRAME | 2Л6-1
6 x Steel Assembly | RIGID_FRAME | 2ОГ2-7
Steel Assembly | RIGID_FRAME | 2Б14-1
Steel Assembly | RIGID_FRAME | 4ПД1-1
Steel Assembly | RIGID_FRAME | 3ПД1-1
2 x Steel Assembly | RIGID_FRAME | 2ПД1-1
Steel Assembly | RIGID_FRAME | 4ОГ2-6
Steel Assembly | RIGID_FRAME | 4ОГ2-5
Steel Assembly | RIGID_FRAME | 4ОГ1-6
Steel Assembly | RIGID_FRAME | 4ОГ1-5
Steel Assembly | RIGID_FRAME | 4ОГ2-4
2 x Steel Assembly | RIGID_FRAME | 4ОГ2-3
Steel Assembly | RIGID_FRAME | 4Л1-2
Steel Assembly | RIGID_FRAME | 4ОГ1-8
2 x Steel Assembly | RIGID_FRAME | 4ОГ1-4
Steel Assembly | RIGID_FRAME | 4ОГ2-7
Steel Assembly | RIGID_FRAME | 4Л1-3
2 x Steel Assembly | RIGID_FRAME | 4ОГ2-2
2 x Steel Assembly | RIGID_FRAME | 4ОГ2-1
2 x Steel Assembly | RIGID_FRAME | 4Л1-1
Steel Assembly | RIGID_FRAME | 4ОГ1-16
Steel Assembly | RIGID_FRAME | 4ОГ2-13
Steel Assembly | RIGID_FRAME | 4ОГ2-14
Steel Assembly | RIGID_FRAME | 4ОГ1-17
Steel Assembly | RIGID_FRAME | 4Л2-4
Steel Assembly | RIGID_FRAME | 4ОГ2-12
Steel Assembly | RIGID_FRAME | 4ОГ2-11
3 x Steel Assembly | RIGID_FRAME | 4ОГ1-9
Steel Assembly | RIGID_FRAME | 4Л2-3
3 x Steel Assembly | RIGID_FRAME | 4ОГ1-7
3 x Steel Assembly | RIGID_FRAME | 4ОГ1-10
2 x Steel Assembly | RIGID_FRAME | 4ОГ2-10
2 x Steel Assembly | RIGID_FRAME | 4ОГ2-9
Steel Assembly | RIGID_FRAME | 4СТ1-2
Steel Assembly | RIGID_FRAME | 4СТ1-1
Steel Assembly | RIGID_FRAME | 4ОГ1-1
Steel Assembly | RIGID_FRAME | 4ОГ1-13
Steel Assembly | RIGID_FRAME | 4ОГ1-12
Steel Assembly | RIGID_FRAME | 4ОГ1-11
Steel Assembly | RIGID_FRAME | 4ОГ1-2
Steel Assembly | RIGID_FRAME | 4ОГ1-3
Steel Assembly | RIGID_FRAME | 4ОГ1-14
Steel Assembly | RIGID_FRAME | 4Б13-4
Steel Assembly | RIGID_FRAME | 4Л6-1
Steel Assembly | RIGID_FRAME | 4Б13-5
14 x Steel Assembly | RIGID_FRAME | 4Б13-2
3 x Steel Assembly | RIGID_FRAME | 4Б13-1
4 x Steel Assembly | RIGID_FRAME | 4КР1-2
Steel Assembly | RIGID_FRAME | 4Б14-3
2 x Steel Assembly | RIGID_FRAME | 4Л2-2
3 x Steel Assembly | RIGID_FRAME | 4Б13-7
3 x Steel Assembly | RIGID_FRAME | 4Б13-6
8 x Steel Assembly | RIGID_FRAME | 4Ш-2
Steel Assembly | RIGID_FRAME | 4Б13-3
4 x Steel Assembly | RIGID_FRAME | 4КР1-1
Steel Assembly | RIGID_FRAME | 4Б14-2
Steel Assembly | RIGID_FRAME | 4Б14-1
Steel Assembly | RIGID_FRAME | 4Б14-5
Steel Assembly | RIGID_FRAME | 4Б14-4
Steel Assembly | RIGID_FRAME | 4Б-1
Steel Assembly | RIGID_FRAME | 4Л2-1
7 x Steel Assembly | RIGID_FRAME | 4РФ2-1
2 x Steel Assembly | RIGID_FRAME | 4ОГ1-15
2 x Steel Assembly |  | 4Н4-11
2 x Steel Assembly | RIGID_FRAME | 4ОГ2-8
Steel Assembly | RIGID_FRAME | 4СФ2-2
Steel Assembly | RIGID_FRAME | 4СФ2-3
Steel Assembly | RIGID_FRAME | 4К1-9
Steel Assembly | RIGID_FRAME | 4К1-7
2 x Steel Assembly |  | 4Н4-2
2 x Steel Assembly |  | 4Н4-1
Steel Assembly | RIGID_FRAME | 4В-5
Steel Assembly | RIGID_FRAME | 4Н3-6
Steel Assembly |  | 4Н4-18
3 x Steel Assembly |  | 4Н4-17
2 x Steel Assembly |  | 4Н4-15
Steel Assembly |  | 4Н4-19
3 x Steel Assembly |  | 4Н4-16
Steel Assembly | RIGID_FRAME | 4Н3-4
3 x Steel Assembly | RIGID_FRAME | 4Н3-5
2 x Steel Assembly | RIGID_FRAME | 4Н3-8
2 x Steel Assembly | RIGID_FRAME | 4Н3-7
Steel Assembly |  | 4Н4-10
Steel Assembly |  | 4Н4-12
Steel Assembly |  | 4Н4-9
2 x Steel Assembly |  | 4Н4-3
Steel Assembly |  | 4Н4-8
Steel Assembly |  | 4Н4-4
2 x Steel Assembly |  | 4Н4-5
2 x Steel Assembly |  | 4Н4-6
Steel Assembly |  | 4Н4-7
Steel Assembly |  | 4Н4-13
Steel Assembly |  | 4Н4-14
Steel Assembly | RIGID_FRAME | 4В-6
Steel Assembly | RIGID_FRAME | 4В-9
Steel Assembly | RIGID_FRAME | 4В-10
Steel Assembly | RIGID_FRAME | 4В-4
Steel Assembly | RIGID_FRAME | 4В-2
Steel Assembly | RIGID_FRAME | 4В-1
Steel Assembly | RIGID_FRAME | 4В-3
Steel Assembly | RIGID_FRAME | 4В-8
Steel Assembly |  | 4Н1-69
Steel Assembly |  | 4Н1-72
Steel Assembly | RIGID_FRAME | 4В-7
Steel Assembly | RIGID_FRAME | 3ОГ2-12
Steel Assembly | RIGID_FRAME | 3ОГ2-11
Steel Assembly | RIGID_FRAME | 3ОГ1-18
Steel Assembly | RIGID_FRAME | 3ОГ1-17
Steel Assembly | RIGID_FRAME | 3ОГ2-10
2 x Steel Assembly | RIGID_FRAME | 3ОГ2-9
Steel Assembly | RIGID_FRAME | 3Л1-5
Steel Assembly | RIGID_FRAME | 3ОГ1-20
2 x Steel Assembly | RIGID_FRAME | 3ОГ1-16
Steel Assembly | RIGID_FRAME | 3ОГ2-13
Steel Assembly | RIGID_FRAME | 3Л1-6
2 x Steel Assembly | RIGID_FRAME | 3ОГ2-8
2 x Steel Assembly | RIGID_FRAME | 3ОГ2-7
2 x Steel Assembly | RIGID_FRAME | 3Л1-4
Steel Assembly | RIGID_FRAME | 3ОГ1-25
Steel Assembly | RIGID_FRAME | 3ОГ2-17
Steel Assembly | RIGID_FRAME | 3ОГ2-18
Steel Assembly | RIGID_FRAME | 3ОГ1-26
Steel Assembly | RIGID_FRAME | 3Л2-4
Steel Assembly | RIGID_FRAME | 3ОГ2-16
Steel Assembly | RIGID_FRAME | 3ОГ2-15
Steel Assembly | RIGID_FRAME | 3Л2-3
3 x Steel Assembly | RIGID_FRAME | 3ОГ1-19
Steel Assembly | RIGID_FRAME | 3СТ1-4
Steel Assembly | RIGID_FRAME | 3СТ1-3
Steel Assembly | RIGID_FRAME | 3ОГ1-13
Steel Assembly | RIGID_FRAME | 3ОГ1-23
Steel Assembly | RIGID_FRAME | 3ОГ1-22
Steel Assembly | RIGID_FRAME | 3ОГ1-21
Steel Assembly | RIGID_FRAME | 3ОГ1-14
Steel Assembly | RIGID_FRAME | 3ОГ1-15
Steel Assembly | RIGID_FRAME | 3ОГ1-24
Steel Assembly | RIGID_FRAME | 3Б13-12
Steel Assembly | RIGID_FRAME | 3Л6-1
Steel Assembly | RIGID_FRAME | 3Б13-13
14 x Steel Assembly | RIGID_FRAME | 3Б13-10
3 x Steel Assembly | RIGID_FRAME | 3Б13-9
4 x Steel Assembly | RIGID_FRAME | 3КР1-4
Steel Assembly | RIGID_FRAME | 3Б14-3
2 x Steel Assembly | RIGID_FRAME | 3Л2-2
3 x Steel Assembly | RIGID_FRAME | 3Б13-15
3 x Steel Assembly | RIGID_FRAME | 3Б13-14
Steel Assembly | RIGID_FRAME | 3Б13-11
4 x Steel Assembly | RIGID_FRAME | 3КР1-3
Steel Assembly | RIGID_FRAME | 3Б14-2
Steel Assembly | RIGID_FRAME | 3Б14-1
Steel Assembly | RIGID_FRAME | 3Б14-5
Steel Assembly | RIGID_FRAME | 3Б14-4
Steel Assembly | RIGID_FRAME | 3Б-2
Steel Assembly | RIGID_FRAME | 3Л2-1
7 x Steel Assembly | RIGID_FRAME | 3РФ2-1
2 x Steel Assembly |  | 3Н4-21
2 x Steel Assembly | RIGID_FRAME | 3ОГ2-14
Steel Assembly | RIGID_FRAME | 3СФ2-2
Steel Assembly | RIGID_FRAME | 3СФ2-3
Steel Assembly | RIGID_FRAME | 3К1-11
Steel Assembly | RIGID_FRAME | 3К1-9
2 x Steel Assembly |  | 3Н4-12
2 x Steel Assembly |  | 3Н4-11
Steel Assembly | RIGID_FRAME | 3В-5
Steel Assembly | RIGID_FRAME | 3Н3-6
Steel Assembly |  | 3Н4-27
3 x Steel Assembly |  | 3Н4-26
3 x Steel Assembly |  | 3Н4-25
Steel Assembly | RIGID_FRAME | 3Н3-4
3 x Steel Assembly | RIGID_FRAME | 3Н3-5
2 x Steel Assembly | RIGID_FRAME | 3Н3-8
2 x Steel Assembly | RIGID_FRAME | 3Н3-7
Steel Assembly |  | 3Н4-20
Steel Assembly |  | 3Н4-22
Steel Assembly |  | 3Н4-19
2 x Steel Assembly |  | 3Н4-13
Steel Assembly |  | 3Н4-18
Steel Assembly |  | 3Н4-14
2 x Steel Assembly |  | 3Н4-15
2 x Steel Assembly |  | 3Н4-16
Steel Assembly |  | 3Н4-17
Steel Assembly |  | 3Н4-23
Steel Assembly |  | 3Н4-24
Steel Assembly | RIGID_FRAME | 3В-6
Steel Assembly | RIGID_FRAME | 3В-9
Steel Assembly | RIGID_FRAME | 3В-10
Steel Assembly | RIGID_FRAME | 3В-4
Steel Assembly | RIGID_FRAME | 3В-2
Steel Assembly | RIGID_FRAME | 3В-1
Steel Assembly | RIGID_FRAME | 3В-3
Steel Assembly | RIGID_FRAME | 3В-8
Steel Assembly |  | 3Н1-67
Steel Assembly |  | 3Н1-70
Steel Assembly | RIGID_FRAME | 3В-7
2 x Steel Assembly | RIGID_FRAME | 2ОГ2-14
2 x Steel Assembly | RIGID_FRAME | 2ОГ2-13
Steel Assembly | RIGID_FRAME | 2ОГ1-29
2 x Steel Assembly | RIGID_FRAME | 2ОГ1-18
2 x Steel Assembly | RIGID_FRAME | 2ОГ2-12
4 x Steel Assembly | RIGID_FRAME | 2ОГ2-11
2 x Steel Assembly | RIGID_FRAME | 2Л1-5
2 x Steel Assembly | RIGID_FRAME | 2ОГ1-22
3 x Steel Assembly | RIGID_FRAME | 2ОГ1-17
2 x Steel Assembly | RIGID_FRAME | 2ОГ2-15
2 x Steel Assembly | RIGID_FRAME | 2Л1-6
4 x Steel Assembly | RIGID_FRAME | 2ОГ2-10
4 x Steel Assembly | RIGID_FRAME | 2ОГ2-9
4 x Steel Assembly | RIGID_FRAME | 2Л1-4
2 x Steel Assembly | RIGID_FRAME | 2ОГ1-26
2 x Steel Assembly | RIGID_FRAME | 2ОГ2-18
2 x Steel Assembly | RIGID_FRAME | 2ОГ2-8
2 x Steel Assembly | RIGID_FRAME | 2ОГ1-27
2 x Steel Assembly | RIGID_FRAME | 2Л2-4
2 x Steel Assembly | RIGID_FRAME | 2ОГ2-17
2 x Steel Assembly | RIGID_FRAME | 2ОГ2-16
2 x Steel Assembly | RIGID_FRAME | 2Л2-3
6 x Steel Assembly | RIGID_FRAME | 2ОГ1-21
2 x Steel Assembly | RIGID_FRAME | 2СТ1-4
2 x Steel Assembly | RIGID_FRAME | 2СТ1-3
Steel Assembly | RIGID_FRAME | 2ОГ1-15
2 x Steel Assembly | RIGID_FRAME | 2ОГ1-24
2 x Steel Assembly | RIGID_FRAME | 2ОГ1-23
Steel Assembly | RIGID_FRAME | 2ОГ1-30
2 x Steel Assembly | RIGID_FRAME | 2ОГ1-16
Steel Assembly | RIGID_FRAME | 2ОГ1-28
2 x Steel Assembly | RIGID_FRAME | 2ОГ1-25
2 x Steel Assembly | RIGID_FRAME | 2Б13-12
Steel Assembly | RIGID_FRAME | 2Б13-16
30 x Steel Assembly | RIGID_FRAME | 2Б13-9
4 x Steel Assembly | RIGID_FRAME | 2Б13-10
8 x Steel Assembly | RIGID_FRAME | 2КР1-4
2 x Steel Assembly | RIGID_FRAME | 2Б14-3
4 x Steel Assembly | RIGID_FRAME | 2Л2-2
6 x Steel Assembly | RIGID_FRAME | 2Б13-15
6 x Steel Assembly | RIGID_FRAME | 2Б13-14
2 x Steel Assembly | RIGID_FRAME | 2Б13-11
8 x Steel Assembly | RIGID_FRAME | 2КР1-3
2 x Steel Assembly | RIGID_FRAME | 2Б14-2
Steel Assembly | RIGID_FRAME | 2Б14-6
Steel Assembly | RIGID_FRAME | 2Б14-7
2 x Steel Assembly | RIGID_FRAME | 2Б14-4
2 x Steel Assembly | RIGID_FRAME | 2Б-2
2 x Steel Assembly | RIGID_FRAME | 2Л2-1
4 x Steel Assembly |  | 2Н4-19
2 x Steel Assembly | RIGID_FRAME | 2К1-11
2 x Steel Assembly | RIGID_FRAME | 2К1-9
4 x Steel Assembly |  | 2Н4-12
4 x Steel Assembly |  | 2Н4-11
Steel Assembly | RIGID_FRAME | 2В-12
2 x Steel Assembly |  | 2Н4-25
6 x Steel Assembly |  | 2Н4-24
6 x Steel Assembly |  | 2Н4-23
Steel Assembly | RIGID_FRAME | 2Н3-7
2 x Steel Assembly |  | 2Н4-18
2 x Steel Assembly |  | 2Н4-20
Steel Assembly |  | 2Н4-27
2 x Steel Assembly |  | 2Н4-26
2 x Steel Assembly |  | 2Н4-17
2 x Steel Assembly |  | 2Н4-13
4 x Steel Assembly |  | 2Н4-14
4 x Steel Assembly |  | 2Н4-15
2 x Steel Assembly |  | 2Н4-16
2 x Steel Assembly |  | 2Н4-21
2 x Steel Assembly |  | 2Н4-22
2 x Steel Assembly | RIGID_FRAME | 2В-6
2 x Steel Assembly | RIGID_FRAME | 2В-7
Steel Assembly | RIGID_FRAME | 2В-11
Steel Assembly | RIGID_FRAME | 2В-9
Steel Assembly | RIGID_FRAME | 2В-8
Steel Assembly | RIGID_FRAME | 2В-10
Steel Assembly | RIGID_FRAME | 2В-13
Steel Assembly |  | 2Н1-39
2 x Steel Assembly |  | 2Н1-61
Steel Assembly | RIGID_FRAME | 1Б-1
Steel Assembly | RIGID_FRAME | 2ОГ1-19
176 x Steel Assembly | RIGID_FRAME | 2Б7-3
25 x Steel Assembly |  | 2Н1-12
7 x Steel Assembly |  | 2Н1-31
11 x Steel Assembly | RIGID_FRAME | 2Б1-2
Steel Assembly | RIGID_FRAME | 2Б14-5
Steel Assembly | RIGID_FRAME | 2ОГ1-31
Steel Assembly | RIGID_FRAME | 2Б13-13
Steel Assembly | RIGID_FRAME | 2В-5
Steel Assembly |  | 2Н1-58
Steel Assembly | RIGID_FRAME | 1К1-2
Steel Assembly | RIGID_FRAME | 1К1-1
2 x Steel Assembly | RIGID_FRAME | 1ОГ1-21
2 x Steel Assembly |  | 1Н4-19
Steel Assembly |  | 1Н4-22
Steel Assembly | RIGID_FRAME | 1Л2-2
3 x Steel Assembly | RIGID_FRAME | 1ОГ1-17
3 x Steel Assembly | RIGID_FRAME | 1Б13-9
Steel Assembly | RIGID_FRAME | 1ОГ2-7
Steel Assembly | RIGID_FRAME | 1ОГ2-8
3 x Steel Assembly | RIGID_FRAME | 1ОГ1-20
3 x Steel Assembly |  | 1Н4-20
Steel Assembly | RIGID_FRAME | 1Л2-1
3 x Steel Assembly | RIGID_FRAME | 1ОГ2-6
3 x Steel Assembly | RIGID_FRAME | 1ОГ2-5
3 x Steel Assembly | RIGID_FRAME | 1ОГ1-19
3 x Steel Assembly |  | 1Н4-21
Steel Assembly | RIGID_FRAME | 1Л2-3
Steel Assembly | RIGID_FRAME | 1Л4-1
2 x Steel Assembly | RIGID_FRAME | 1Б13-10
Steel Assembly | RIGID_FRAME | 1СТ1-1
Steel Assembly | RIGID_FRAME | 1СТ1-2
Steel Assembly | RIGID_FRAME | 1ОГ1-16
Steel Assembly | RIGID_FRAME | 1ОГ1-15
Steel Assembly | RIGID_FRAME | 1Б13-11
8 x Steel Assembly | RIGID_FRAME | 1Ш-2
4 x Steel Assembly | RIGID_FRAME | 1Н3-3
2 x Steel Assembly | RIGID_FRAME | 1Н3-6
2 x Steel Assembly | RIGID_FRAME | 1Н3-5
Steel Assembly | RIGID_FRAME | 1Н3-4
2 x Steel Assembly |  | 1Н4-11
Steel Assembly |  | 1Н4-10
Steel Assembly |  | 1Н4-12
Steel Assembly |  | 1Н4-13
Steel Assembly |  | 1Н4-9
2 x Steel Assembly |  | 1Н4-1
Steel Assembly |  | 1Н4-7
Steel Assembly |  | 1Н4-2
2 x Steel Assembly |  | 1Н4-3
2 x Steel Assembly |  | 1Н4-4
2 x Steel Assembly |  | 1Н4-5
Steel Assembly |  | 1Н4-6
Steel Assembly |  | 1Н4-15
Steel Assembly |  | 1Н4-16
Steel Assembly |  | 1Н4-17
Steel Assembly | RIGID_FRAME | 1ОГ1-2
Steel Assembly | RIGID_FRAME | 1Б14-1
Steel Assembly | RIGID_FRAME | 1ОГ1-12
Steel Assembly | RIGID_FRAME | 1Б14-4
Steel Assembly | RIGID_FRAME | 1ОГ1-11
Steel Assembly |  | 1Н4-18
Steel Assembly | RIGID_FRAME | 1ОГ1-10
2 x Steel Assembly | RIGID_FRAME | 1ОГ1-3
Steel Assembly | RIGID_FRAME | 1ОГ1-4
3 x Steel Assembly | RIGID_FRAME | 1Б13-4
Steel Assembly | RIGID_FRAME | 1ОГ1-9
Steel Assembly | RIGID_FRAME | 1ОГ1-7
Steel Assembly | RIGID_FRAME | 1Б14-3
Steel Assembly | RIGID_FRAME | 1ОГ1-13
Steel Assembly | RIGID_FRAME | 1ОГ1-8
Steel Assembly | RIGID_FRAME | 1ОГ1-5
Steel Assembly | RIGID_FRAME | 1Л1-2
Steel Assembly | RIGID_FRAME | 1ОГ1-6
4 x Steel Assembly | RIGID_FRAME | 1ОГ2-2
4 x Steel Assembly | RIGID_FRAME | 1ОГ2-1
Steel Assembly |  | 1Н4-8
Steel Assembly | RIGID_FRAME | 1Л1-1
Steel Assembly | RIGID_FRAME | 1Л1-4
Steel Assembly | RIGID_FRAME | 1Л1-3
3 x Steel Assembly | RIGID_FRAME | 2ОГ1-14
6 x Steel Assembly | RIGID_FRAME | 2ОГ1-13
Steel Assembly | RIGID_FRAME | 4ОГ1-18
2 x Steel Assembly | RIGID_FRAME | 4ОГ1-19
Steel Assembly | RIGID_FRAME | 3ОГ1-27
2 x Steel Assembly | RIGID_FRAME | 3ОГ1-28
Steel Assembly | RIGID_FRAME | 1ОГ2-3
Steel Assembly | RIGID_FRAME | 1ОГ2-4
Steel Assembly | RIGID_FRAME | 1ОГ1-14
2 x Steel Assembly | RIGID_FRAME | 1ОГ1-18
Steel Assembly | RIGID_FRAME | 1В-7
Steel Assembly | RIGID_FRAME | 1В-10
Steel Assembly | RIGID_FRAME | 1В-11
7 x Steel Assembly | RIGID_FRAME | 1РФ2-1
Steel Assembly | RIGID_FRAME | 1В-6
Steel Assembly | RIGID_FRAME | 1В-4
Steel Assembly | RIGID_FRAME | 1В-5
Steel Assembly | RIGID_FRAME | 1В-2
Steel Assembly | RIGID_FRAME | 1В-1
Steel Assembly | RIGID_FRAME | 1В-3
Steel Assembly | RIGID_FRAME | 1В-9
Steel Assembly |  | 1Н1-48
Steel Assembly |  | 1Н4-14
Steel Assembly | RIGID_FRAME | 1Б13-8
Steel Assembly | RIGID_FRAME | 1Б13-6
Steel Assembly | RIGID_FRAME | 1Б13-7
Steel Assembly | RIGID_FRAME | 1Б14-2
Steel Assembly | RIGID_FRAME | 1СФ2-2
Steel Assembly | RIGID_FRAME | 1СФ2-3
Steel Assembly | RIGID_FRAME | 1В-8
Steel Assembly | RIGID_FRAME | 1Л6-1
15 x Steel Assembly | RIGID_FRAME | 1Б13-5
4 x Steel Assembly | RIGID_FRAME | 1КР1-1
4 x Steel Assembly | RIGID_FRAME | 1КР1-2
2 x Steel Assembly | RIGID_FRAME | 1К1-7
Steel Assembly |  | 1Н1-9
Steel Assembly |  | 1Н1-10
2 x Steel Assembly |  | 1Н1-17
2 x Steel Assembly |  | 1Н1-18
Steel Assembly |  | 1ПД-3
Steel Assembly |  | 1ПД-1
Steel Assembly |  | 1ПД-2
Steel Assembly |  | 1Н1-1
Steel Assembly |  | 1Н1-2
Steel Assembly |  | 1Н1-5
Steel Assembly |  | 1Н1-6
Steel Assembly |  | 1Н1-35
Steel Assembly |  | 1Н1-13
Steel Assembly |  | 1Н1-14
Steel Assembly |  | 1Н1-15
Steel Assembly |  | 1Н1-16
Steel Assembly |  | 1Н1-19
Steel Assembly |  | 1Н1-20
Steel Assembly |  | 1Н1-21
Steel Assembly |  | 1Н1-22
Steel Assembly |  | 1Н1-36
2 x Steel Assembly |  | 1Н1-37
Steel Assembly |  | 1Н1-39
Steel Assembly |  | 1Н1-40
Steel Assembly |  | 1Н1-41
Steel Assembly |  | 1Н1-33
Steel Assembly |  | 1Н1-34
Steel Assembly |  | 1Н1-42
Steel Assembly |  | 1Н1-43
Steel Assembly |  | 1Н1-23
2 x Steel Assembly |  | 1Н1-24
Steel Assembly |  | 1Н1-25
2 x Steel Assembly |  | 1Н1-26
2 x Steel Assembly |  | 1Н1-27
Steel Assembly |  | 1Н1-28
Steel Assembly |  | 1Н1-29
Steel Assembly |  | 1Н1-30
Steel Assembly |  | 1Н1-31
Steel Assembly |  | 1Н1-3
Steel Assembly |  | 1Н1-4
Steel Assembly |  | 1Н1-7
Steel Assembly |  | 1Н1-8
Steel Assembly |  | 1Н1-11
Steel Assembly |  | 1Н1-12
Steel Assembly |  | 1Н1-32
Steel Assembly |  | 1Н1-44
Steel Assembly |  | 1Н1-45
Steel Assembly |  | 1Н1-46
Steel Assembly |  | 1Н1-47
Steel Assembly |  | 1Н1-65
Steel Assembly |  | 1Н1-68
Steel Assembly |  | 1Н1-66
Steel Assembly |  | 1Н1-67
Steel Assembly |  | 1Н1-64
Steel Assembly |  | 1Н1-62
Steel Assembly |  | 1Н1-63
Steel Assembly |  | 1Н1-61
2 x Steel Assembly |  | 1Н1-55
Steel Assembly |  | 1Н1-56
Steel Assembly |  | 1Н1-49
Steel Assembly |  | 1Н1-50
Steel Assembly |  | 1Н1-57
Steel Assembly |  | 1Н1-58
Steel Assembly |  | 1Н1-51
Steel Assembly |  | 1Н1-52
Steel Assembly |  | 1Н1-59
Steel Assembly |  | 1Н1-60
Steel Assembly |  | 1Н1-53
Steel Assembly |  | 1Н1-54
Steel Assembly |  | 1Н1-79
Steel Assembly |  | 1Н1-80
Steel Assembly |  | 1Н1-81
Steel Assembly |  | 1Н1-82
Steel Assembly |  | 1Н1-83
Steel Assembly |  | 1Н1-84
Steel Assembly |  | 1Н1-85
Steel Assembly |  | 1Н1-86
Steel Assembly |  | 1Н1-87
Steel Assembly |  | 1Н1-88
Steel Assembly |  | 1Н1-89
Steel Assembly |  | 1Н1-90
2 x Steel Assembly |  | 1Н1-69
Steel Assembly |  | 1Н1-70
Steel Assembly |  | 1Н1-71
Steel Assembly |  | 1Н1-72
Steel Assembly |  | 1Н1-73
Steel Assembly |  | 1Н1-74
Steel Assembly |  | 1Н1-75
Steel Assembly |  | 1Н1-76
Steel Assembly |  | 1Н1-77
Steel Assembly |  | 1Н1-78
2 x Steel Assembly |  | 1Н1-102
2 x Steel Assembly |  | 1Н1-103
Steel Assembly |  | 1Н1-113
Steel Assembly |  | 1Н1-114
Steel Assembly |  | 1Н1-115
Steel Assembly |  | 1Н1-116
Steel Assembly |  | 1Н1-117
Steel Assembly |  | 1Н1-118
Steel Assembly |  | 1Н1-119
Steel Assembly |  | 1Н1-120
2 x Steel Assembly |  | 1Н1-112
Steel Assembly |  | 1Н1-104
Steel Assembly |  | 1Н1-105
Steel Assembly |  | 1Н1-106
Steel Assembly |  | 1Н1-107
Steel Assembly |  | 1Н1-108
Steel Assembly |  | 1Н1-109
Steel Assembly |  | 1Н1-110
Steel Assembly |  | 1Н1-111
2 x Steel Assembly |  | 2Н1-44
2 x Steel Assembly |  | 2Н1-45
2 x Steel Assembly |  | 2Н1-56
2 x Steel Assembly |  | 2Н1-57
2 x Steel Assembly |  | 2Н1-70
2 x Steel Assembly |  | 2Н1-71
2 x Steel Assembly |  | 2Н1-59
2 x Steel Assembly |  | 2Н1-60
2 x Steel Assembly |  | 2Н1-42
Steel Assembly |  | 2Н1-43
2 x Steel Assembly |  | 2Н1-54
2 x Steel Assembly |  | 2Н1-55
2 x Steel Assembly |  | 2Н1-73
2 x Steel Assembly |  | 2Н1-74
2 x Steel Assembly |  | 2Н1-64
2 x Steel Assembly |  | 2Н1-65
3 x Steel Assembly |  | 2Н1-40
Steel Assembly |  | 2Н1-41
Steel Assembly |  | 2Н1-46
Steel Assembly |  | 2Н1-52
Steel Assembly |  | 2Н1-53
Steel Assembly |  | 2Н1-49
2 x Steel Assembly |  | 2Н1-68
2 x Steel Assembly |  | 2Н1-72
2 x Steel Assembly |  | 2Н1-67
2 x Steel Assembly |  | 2Н1-62
2 x Steel Assembly |  | 2Н1-63
8 x Steel Assembly |  | 2Н1-32
8 x Steel Assembly |  | 2Н1-33
8 x Steel Assembly |  | 2Н1-36
8 x Steel Assembly |  | 2Н1-37
10 x Steel Assembly |  | 2Н1-15
10 x Steel Assembly |  | 2Н1-16
10 x Steel Assembly |  | 2Н1-19
10 x Steel Assembly |  | 2Н1-20
2 x Steel Assembly |  | 2Н1-50
4 x Steel Assembly |  | 2Н1-51
2 x Steel Assembly |  | 2Н1-66
2 x Steel Assembly |  | 2Н1-47
4 x Steel Assembly |  | 2Н1-48
2 x Steel Assembly |  | 2Н1-69
Steel Assembly |  | 2Н1-75
Steel Assembly |  | 3Н1-50
Steel Assembly |  | 3Н1-51
Steel Assembly |  | 3Н1-63
Steel Assembly |  | 3Н1-64
2 x Steel Assembly |  | 3Н1-54
Steel Assembly |  | 3Н1-55
Steel Assembly |  | 3Н1-61
2 x Steel Assembly |  | 3Н1-62
Steel Assembly |  | 3Н1-52
Steel Assembly |  | 3Н1-53
Steel Assembly |  | 3Н1-65
Steel Assembly |  | 3Н1-66
2 x Steel Assembly |  | 2Н1-1
2 x Steel Assembly |  | 2Н1-2
2 x Steel Assembly |  | 2Н1-3
2 x Steel Assembly |  | 2Н1-4
2 x Steel Assembly |  | 2Н1-5
2 x Steel Assembly |  | 2Н1-6
2 x Steel Assembly |  | 2Н1-7
2 x Steel Assembly |  | 2Н1-8
2 x Steel Assembly |  | 2Н1-9
2 x Steel Assembly |  | 2Н1-10
2 x Steel Assembly |  | 2Н1-11
Steel Assembly |  | 3Н1-1
Steel Assembly |  | 3Н1-2
Steel Assembly |  | 3Н1-3
Steel Assembly |  | 3Н1-4
Steel Assembly |  | 3Н1-5
Steel Assembly |  | 3Н1-6
Steel Assembly |  | 3Н1-7
Steel Assembly |  | 3Н1-8
Steel Assembly |  | 3Н1-9
Steel Assembly |  | 3Н1-10
Steel Assembly |  | 3Н1-11
Steel Assembly |  | 4Н1-1
Steel Assembly |  | 4Н1-2
Steel Assembly |  | 4Н1-3
Steel Assembly |  | 4Н1-4
Steel Assembly |  | 4Н1-5
Steel Assembly |  | 4Н1-6
Steel Assembly |  | 4Н1-7
Steel Assembly |  | 4Н1-8
Steel Assembly |  | 4Н1-9
Steel Assembly |  | 4Н1-10
Steel Assembly |  | 4Н1-11
Steel Assembly |  | 3Н1-83
Steel Assembly |  | 3Н1-84
Steel Assembly |  | 3Н1-68
Steel Assembly |  | 3Н1-69
Steel Assembly |  | 3Н1-87
Steel Assembly |  | 3Н1-88
Steel Assembly |  | 3Н1-73
Steel Assembly |  | 3Н1-74
Steel Assembly |  | 3Н1-81
Steel Assembly |  | 3Н1-85
Steel Assembly |  | 3Н1-86
Steel Assembly |  | 3Н1-76
Steel Assembly |  | 3Н1-71
Steel Assembly |  | 3Н1-72
Steel Assembly |  | 3Н1-75
Steel Assembly |  | 3Н1-82
Steel Assembly |  | 4Н1-65
Steel Assembly |  | 4Н1-66
Steel Assembly |  | 4Н1-55
Steel Assembly |  | 4Н1-56
Steel Assembly |  | 4Н1-67
Steel Assembly |  | 4Н1-68
Steel Assembly |  | 4Н1-57
Steel Assembly |  | 4Н1-58
2 x Steel Assembly |  | 4Н1-63
2 x Steel Assembly |  | 4Н1-64
2 x Steel Assembly |  | 4Н1-59
Steel Assembly |  | 4Н1-60
