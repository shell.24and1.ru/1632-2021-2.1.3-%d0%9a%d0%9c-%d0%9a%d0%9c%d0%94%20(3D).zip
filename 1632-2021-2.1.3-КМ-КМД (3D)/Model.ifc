Properties of the parts of a building model (IFC2X3), part 2 of 3

# IfcElementAssembly (11390)
Name | PredefinedType | ASSEMBLY_POS
Steel Assembly |  | 4Н1-81
Steel Assembly |  | 4Н1-82
Steel Assembly |  | 4Н1-83
Steel Assembly |  | 4Н1-70
Steel Assembly |  | 4Н1-71
Steel Assembly |  | 4Н1-86
Steel Assembly |  | 4Н1-87
Steel Assembly |  | 4Н1-75
Steel Assembly |  | 4Н1-76
Steel Assembly |  | 4Н1-80
Steel Assembly |  | 4Н1-84
Steel Assembly |  | 4Н1-85
Steel Assembly |  | 4Н1-77
Steel Assembly |  | 4Н1-73
Steel Assembly |  | 4Н1-74
10 x Steel Assembly |  | 2Н1-23
10 x Steel Assembly |  | 2Н1-24
10 x Steel Assembly |  | 2Н1-25
10 x Steel Assembly |  | 2Н1-26
10 x Steel Assembly |  | 2Н1-27
10 x Steel Assembly |  | 2Н1-28
10 x Steel Assembly |  | 2Н1-29
10 x Steel Assembly |  | 2Н1-30
24 x Steel Assembly |  | 2Н1-22
7 x Steel Assembly |  | 1Н1-91
7 x Steel Assembly |  | 1Н1-92
Steel Assembly |  | 1Н1-93
Steel Assembly |  | 1Н1-94
Steel Assembly |  | 1Н1-95
Steel Assembly |  | 1Н1-96
Steel Assembly |  | 1Н1-97
Steel Assembly |  | 1Н1-98
Steel Assembly |  | 1Н1-99
Steel Assembly |  | 1Н1-100
7 x Steel Assembly |  | 1Н1-101
2 x Steel Assembly |  | 1Н1-121
2 x Steel Assembly |  | 1Н1-122
Steel Assembly |  | 1Н1-123
2 x Steel Assembly |  | 1Н1-124
2 x Steel Assembly |  | 1Н1-125
2 x Steel Assembly |  | 1Н1-126
2 x Steel Assembly |  | 1Н1-127
2 x Steel Assembly |  | 1Н1-128
2 x Steel Assembly |  | 1Н1-129
2 x Steel Assembly |  | 1Н1-130
2 x Steel Assembly |  | 1Н1-131
2 x Steel Assembly |  | 1Н1-132
2 x Steel Assembly |  | 1Н1-133
2 x Steel Assembly |  | 1Н1-134
2 x Steel Assembly |  | 1Н1-135
2 x Steel Assembly |  | 1Н1-136
2 x Steel Assembly |  | 1Н1-137
2 x Steel Assembly |  | 1Н1-138
2 x Steel Assembly |  | 1Н1-139
2 x Steel Assembly |  | 1Н1-140
2 x Steel Assembly |  | 1Н1-141
2 x Steel Assembly |  | 1Н1-142
2 x Steel Assembly |  | 1Н1-143
2 x Steel Assembly |  | 1Н1-144
Steel Assembly |  | 1Н1-38
8 x Steel Assembly |  | 2Н1-14
8 x Steel Assembly |  | 2Н1-17
8 x Steel Assembly |  | 2Н1-18
8 x Steel Assembly |  | 2Н1-21
6 x Steel Assembly |  | 2Н1-34
6 x Steel Assembly |  | 2Н1-35
6 x Steel Assembly |  | 2Н1-38
4 x Steel Assembly |  | 3Н1-12
4 x Steel Assembly |  | 3Н1-13
2 x Steel Assembly |  | 3Н1-14
2 x Steel Assembly |  | 3Н1-15
2 x Steel Assembly |  | 3Н1-16
2 x Steel Assembly |  | 3Н1-17
2 x Steel Assembly |  | 3Н1-18
2 x Steel Assembly |  | 3Н1-19
2 x Steel Assembly |  | 3Н1-20
2 x Steel Assembly |  | 3Н1-21
4 x Steel Assembly |  | 3Н1-22
Steel Assembly |  | 3Н1-23
Steel Assembly |  | 3Н1-24
Steel Assembly |  | 3Н1-25
Steel Assembly |  | 3Н1-26
Steel Assembly |  | 3Н1-27
Steel Assembly |  | 3Н1-28
Steel Assembly |  | 3Н1-29
Steel Assembly |  | 3Н1-30
Steel Assembly |  | 3Н1-31
Steel Assembly |  | 3Н1-32
Steel Assembly |  | 3Н1-33
Steel Assembly |  | 3Н1-34
Steel Assembly |  | 3Н1-35
Steel Assembly |  | 3Н1-36
Steel Assembly |  | 3Н1-37
Steel Assembly |  | 3Н1-38
2 x Steel Assembly |  | 3Н1-77
2 x Steel Assembly |  | 3Н1-78
2 x Steel Assembly |  | 3Н1-79
2 x Steel Assembly |  | 3Н1-80
2 x Steel Assembly |  | 3Н1-39
2 x Steel Assembly |  | 3Н1-40
Steel Assembly |  | 3Н1-56
Steel Assembly |  | 3Н1-57
Steel Assembly |  | 3Н1-58
Steel Assembly |  | 3Н1-59
Steel Assembly |  | 3Н1-60
Steel Assembly |  | 3Н1-41
Steel Assembly |  | 3Н1-42
Steel Assembly |  | 3Н1-43
Steel Assembly |  | 3Н1-44
Steel Assembly |  | 3Н1-45
Steel Assembly |  | 3Н1-46
Steel Assembly |  | 3Н1-47
Steel Assembly |  | 3Н1-48
Steel Assembly |  | 3Н1-49
7 x Steel Assembly |  | 3Н1-89
7 x Steel Assembly |  | 3Н1-90
2 x Steel Assembly |  | 3Н1-91
2 x Steel Assembly |  | 3Н1-92
2 x Steel Assembly |  | 3Н1-93
2 x Steel Assembly |  | 3Н1-94
2 x Steel Assembly |  | 3Н1-95
2 x Steel Assembly |  | 3Н1-96
2 x Steel Assembly |  | 3Н1-97
2 x Steel Assembly |  | 3Н1-98
7 x Steel Assembly |  | 3Н1-99
Steel Assembly |  | 3Н1-100
Steel Assembly |  | 3Н1-101
Steel Assembly |  | 3Н1-102
Steel Assembly |  | 3Н1-103
2 x Steel Assembly |  | 3Н1-104
2 x Steel Assembly |  | 3Н1-105
2 x Steel Assembly |  | 3Н1-106
2 x Steel Assembly |  | 3Н1-107
Steel Assembly |  | 3Н1-108
Steel Assembly |  | 3Н1-109
Steel Assembly |  | 3Н1-110
Steel Assembly |  | 3Н1-111
Steel Assembly |  | 3Н1-112
Steel Assembly |  | 3Н1-113
Steel Assembly |  | 3Н1-114
Steel Assembly |  | 3Н1-115
Steel Assembly |  | 3Н1-116
Steel Assembly |  | 3Н1-117
Steel Assembly |  | 3Н1-118
Steel Assembly |  | 3Н1-119
Steel Assembly |  | 3Н1-120
Steel Assembly |  | 3Н1-121
Steel Assembly |  | 3Н1-122
Steel Assembly |  | 3Н1-123
Steel Assembly |  | 3Н1-124
Steel Assembly |  | 3Н1-125
Steel Assembly |  | 3Н1-126
Steel Assembly |  | 3Н1-127
Steel Assembly |  | 3Н1-128
Steel Assembly |  | 3Н1-129
Steel Assembly |  | 3Н1-130
Steel Assembly |  | 3Н1-131
11 x Steel Assembly |  | 4Н1-12
11 x Steel Assembly |  | 4Н1-13
3 x Steel Assembly |  | 4Н1-14
3 x Steel Assembly |  | 4Н1-15
3 x Steel Assembly |  | 4Н1-16
2 x Steel Assembly |  | 4Н1-17
Steel Assembly |  | 4Н1-18
Steel Assembly |  | 4Н1-19
Steel Assembly |  | 4Н1-20
Steel Assembly |  | 4Н1-21
10 x Steel Assembly |  | 4Н1-22
Steel Assembly |  | 4Н1-23
2 x Steel Assembly |  | 4Н1-24
2 x Steel Assembly |  | 4Н1-25
Steel Assembly |  | 4Н1-26
Steel Assembly |  | 4Н1-27
Steel Assembly |  | 4Н1-28
Steel Assembly |  | 4Н1-29
Steel Assembly |  | 4Н1-30
2 x Steel Assembly |  | 4Н1-31
2 x Steel Assembly |  | 4Н1-32
2 x Steel Assembly |  | 4Н1-33
2 x Steel Assembly |  | 4Н1-34
Steel Assembly |  | 4Н1-35
Steel Assembly |  | 4Н1-36
Steel Assembly |  | 4Н1-37
Steel Assembly |  | 4Н1-38
2 x Steel Assembly |  | 4Н1-39
2 x Steel Assembly |  | 4Н1-40
2 x Steel Assembly |  | 4Н1-41
2 x Steel Assembly |  | 4Н1-42
Steel Assembly |  | 4Н1-43
Steel Assembly |  | 4Н1-44
Steel Assembly |  | 4Н1-45
Steel Assembly |  | 4Н1-46
Steel Assembly |  | 4Н1-78
Steel Assembly |  | 4Н1-79
Steel Assembly |  | 4Н1-61
Steel Assembly |  | 4Н1-62
2 x Steel Assembly |  | 4Н1-47
2 x Steel Assembly |  | 4Н1-48
2 x Steel Assembly |  | 4Н1-49
2 x Steel Assembly |  | 4Н1-50
Steel Assembly |  | 4Н1-51
Steel Assembly |  | 4Н1-52
Steel Assembly |  | 4Н1-53
Steel Assembly |  | 4Н1-54
Steel Assembly |  | 4Н1-98
Steel Assembly |  | 4Н1-99
Steel Assembly |  | 4Н1-100
Steel Assembly |  | 4Н1-101
5 x Steel Assembly |  | 4Н1-88
Steel Assembly |  | 4Н1-102
Steel Assembly |  | 4Н1-103
5 x Steel Assembly |  | 4Н1-91
Steel Assembly |  | 4Н1-96
Steel Assembly |  | 4Н1-97
Steel Assembly |  | 4Н1-94
Steel Assembly |  | 4Н1-95
Steel Assembly |  | 4Н1-92
Steel Assembly |  | 4Н1-93
Steel Assembly |  | 4Н1-89
Steel Assembly |  | 4Н1-90
68 x Steel Assembly | RIGID_FRAME | 1ЗД2-1
68 x Steel Assembly | RIGID_FRAME | 1ЗД2-2
66 x Steel Assembly | RIGID_FRAME | 4ЗД1-2
2 x Steel Assembly | RIGID_FRAME | 4Б4-3
2 x Steel Assembly | RIGID_FRAME | 4Б4-6
102 x Steel Assembly | RIGID_FRAME | 3ЗД1-2
102 x Steel Assembly | RIGID_FRAME | 3ЗД1-1
204 x Steel Assembly | RIGID_FRAME | 2ЗД1-2
204 x Steel Assembly | RIGID_FRAME | 2ЗД1-1
62 x Steel Assembly | RIGID_FRAME | 1ЗД1-2
62 x Steel Assembly | RIGID_FRAME | 1ЗД1-1
Steel Assembly | RIGID_FRAME | 1Б4-2
Steel Assembly | RIGID_FRAME | 1Б4-1
2 x Steel Assembly | RIGID_FRAME | 1Б4-3
2 x Steel Assembly | RIGID_FRAME | 1Б4-4
2 x Steel Assembly | RIGID_FRAME | 1Б4-5
Steel Assembly | RIGID_FRAME | 1Б4-7
Steel Assembly | RIGID_FRAME | 1Б4-6
Steel Assembly | RIGID_FRAME | 1Б4-11
Steel Assembly | RIGID_FRAME | 1Б4-10
4 x Steel Assembly | RIGID_FRAME | 1Б4-14
4 x Steel Assembly | RIGID_FRAME | 1Б4-17
4 x Steel Assembly | RIGID_FRAME | 1Б4-20
6 x Steel Assembly | RIGID_FRAME | 2Б4-2
4 x Steel Assembly | RIGID_FRAME | 2Б4-5
16 x Steel Assembly | RIGID_FRAME | 2Б4-8
12 x Steel Assembly | RIGID_FRAME | 2Б4-11
12 x Steel Assembly | RIGID_FRAME | 2Б4-14
2 x Steel Assembly | RIGID_FRAME | 2Б4-17
2 x Steel Assembly | RIGID_FRAME | 2Б4-21
2 x Steel Assembly | RIGID_FRAME | 2Б4-26
2 x Steel Assembly | RIGID_FRAME | 2Б4-25
3 x Steel Assembly | RIGID_FRAME | 3Б4-2
2 x Steel Assembly | RIGID_FRAME | 3Б4-5
2 x Steel Assembly | RIGID_FRAME | 3Б4-8
2 x Steel Assembly | RIGID_FRAME | 3Б4-11
2 x Steel Assembly | RIGID_FRAME | 3Б4-14
2 x Steel Assembly | RIGID_FRAME | 3Б4-17
Steel Assembly | RIGID_FRAME | 3Б4-20
Steel Assembly | RIGID_FRAME | 3Б4-24
Steel Assembly | RIGID_FRAME | 3Б4-29
Steel Assembly | RIGID_FRAME | 3Б4-28
4 x Steel Assembly | RIGID_FRAME | 3Б4-32
2 x Steel Assembly | RIGID_FRAME | 3Б4-35
2 x Steel Assembly | RIGID_FRAME | 3Б4-38
2 x Steel Assembly | RIGID_FRAME | 3Б4-41
2 x Steel Assembly | RIGID_FRAME | 3Б4-44
2 x Steel Assembly | RIGID_FRAME | 4Б4-9
2 x Steel Assembly | RIGID_FRAME | 4Б4-12
2 x Steel Assembly | RIGID_FRAME | 4Б4-15
2 x Steel Assembly | RIGID_FRAME | 4Б4-18
Steel Assembly | RIGID_FRAME | 4Б4-21
Steel Assembly | RIGID_FRAME | 1Б4-9
Steel Assembly | RIGID_FRAME | 1Б4-8
2 x Steel Assembly | RIGID_FRAME | 1Б4-13
2 x Steel Assembly | RIGID_FRAME | 1Б4-12
2 x Steel Assembly | RIGID_FRAME | 1Б4-16
2 x Steel Assembly | RIGID_FRAME | 1Б4-15
2 x Steel Assembly | RIGID_FRAME | 1Б4-19
2 x Steel Assembly | RIGID_FRAME | 1Б4-18
2 x Steel Assembly | RIGID_FRAME | 2Б4-1
2 x Steel Assembly | RIGID_FRAME | 2Б4-4
2 x Steel Assembly | RIGID_FRAME | 2Б4-3
8 x Steel Assembly | RIGID_FRAME | 2Б4-7
8 x Steel Assembly | RIGID_FRAME | 2Б4-6
6 x Steel Assembly | RIGID_FRAME | 2Б4-10
7 x Steel Assembly | RIGID_FRAME | 2Б4-9
6 x Steel Assembly | RIGID_FRAME | 2Б4-13
6 x Steel Assembly | RIGID_FRAME | 2Б4-12
2 x Steel Assembly | RIGID_FRAME | 2Б4-16
Steel Assembly | RIGID_FRAME | 2Б4-15
2 x Steel Assembly | RIGID_FRAME | 2Б4-20
2 x Steel Assembly | RIGID_FRAME | 2Б4-19
2 x Steel Assembly | RIGID_FRAME | 2Б4-24
2 x Steel Assembly | RIGID_FRAME | 2Б4-23
Steel Assembly | RIGID_FRAME | 3Б4-1
Steel Assembly | RIGID_FRAME | 3Б4-4
Steel Assembly | RIGID_FRAME | 3Б4-3
Steel Assembly | RIGID_FRAME | 3Б4-7
Steel Assembly | RIGID_FRAME | 3Б4-6
Steel Assembly | RIGID_FRAME | 3Б4-10
Steel Assembly | RIGID_FRAME | 3Б4-9
Steel Assembly | RIGID_FRAME | 3Б4-13
Steel Assembly | RIGID_FRAME | 3Б4-12
Steel Assembly | RIGID_FRAME | 3Б4-16
Steel Assembly | RIGID_FRAME | 3Б4-15
Steel Assembly | RIGID_FRAME | 3Б4-19
Steel Assembly | RIGID_FRAME | 3Б4-18
Steel Assembly | RIGID_FRAME | 3Б4-23
Steel Assembly | RIGID_FRAME | 3Б4-22
Steel Assembly | RIGID_FRAME | 3Б4-27
Steel Assembly | RIGID_FRAME | 3Б4-26
2 x Steel Assembly | RIGID_FRAME | 3Б4-31
2 x Steel Assembly | RIGID_FRAME | 3Б4-30
Steel Assembly | RIGID_FRAME | 3Б4-34
Steel Assembly | RIGID_FRAME | 3Б4-33
Steel Assembly | RIGID_FRAME | 3Б4-37
Steel Assembly | RIGID_FRAME | 3Б4-36
Steel Assembly | RIGID_FRAME | 3Б4-40
Steel Assembly | RIGID_FRAME | 3Б4-39
Steel Assembly | RIGID_FRAME | 3Б4-43
Steel Assembly | RIGID_FRAME | 3Б4-42
Steel Assembly | RIGID_FRAME | 4Б4-2
Steel Assembly | RIGID_FRAME | 4Б4-1
Steel Assembly | RIGID_FRAME | 4Б4-5
Steel Assembly | RIGID_FRAME | 4Б4-4
Steel Assembly | RIGID_FRAME | 4Б4-8
Steel Assembly | RIGID_FRAME | 4Б4-7
Steel Assembly | RIGID_FRAME | 4Б4-11
Steel Assembly | RIGID_FRAME | 4Б4-10
2 x Steel Assembly | RIGID_FRAME | 4Б4-14
2 x Steel Assembly | RIGID_FRAME | 4Б4-13
2 x Steel Assembly | RIGID_FRAME | 4Б4-17
2 x Steel Assembly | RIGID_FRAME | 4Б4-16
Steel Assembly | RIGID_FRAME | 4Б4-20
2 x Steel Assembly | RIGID_FRAME | 4Б4-19
Steel Assembly | RIGID_FRAME | 4Б4-24
Steel Assembly | RIGID_FRAME | 4Б4-23
Steel Assembly | RIGID_FRAME | 4Б4-26
Steel Assembly | RIGID_FRAME | 4Б4-25
Steel Assembly | RIGID_FRAME | 4Б4-29
Steel Assembly | RIGID_FRAME | 4Б4-28
Steel Assembly | RIGID_FRAME | 4Б4-27
2 x Steel Assembly | RIGID_FRAME | 3РС11-3
2 x Steel Assembly |  | 1Щ1-1
2 x Steel Assembly |  | 1Щ1-2
24 x Steel Assembly | RIGID_FRAME | 1ПТ-1
24 x Steel Assembly | RIGID_FRAME | 1М-3
4 x Steel Assembly |  | 1Щ1-3
48 x Steel Assembly | RIGID_FRAME | 2ПТ-1
16 x Steel Assembly |  | 2Щ1-1
48 x Steel Assembly | RIGID_FRAME | 2М-2
24 x Steel Assembly | RIGID_FRAME | 3ПТ-1
8 x Steel Assembly |  | 3Щ1-1
24 x Steel Assembly | RIGID_FRAME | 3М-2
24 x Steel Assembly | RIGID_FRAME | 4ПТ-1
8 x Steel Assembly |  | 4Щ1-1
24 x Steel Assembly | RIGID_FRAME | 4М-2
Steel Assembly | RIGID_FRAME | 1РС9-1
Steel Assembly | RIGID_FRAME | 1РС8-2
Steel Assembly | RIGID_FRAME | 1РС8-4
2 x Steel Assembly | RIGID_FRAME | 1РС8-6
Steel Assembly | RIGID_FRAME | 1РС8-1
Steel Assembly | RIGID_FRAME | 1РС8-3
2 x Steel Assembly | RIGID_FRAME | 1РС8-5
Steel Assembly | RIGID_FRAME | 1РС7-3
Steel Assembly | RIGID_FRAME | 1РС8-7
Steel Assembly | RIGID_FRAME | 1РС7-2
7 x Steel Assembly | RIGID_FRAME | 1РС7-1
25 x Steel Assembly | RIGID_FRAME | 2РС7-1
Steel Assembly | RIGID_FRAME | 2РС7-2
2 x Steel Assembly | RIGID_FRAME | 2РС7-3
3 x Steel Assembly | RIGID_FRAME | 3РС7-1
2 x Steel Assembly | RIGID_FRAME | 3РС7-3
Steel Assembly | RIGID_FRAME | 3РС7-2
7 x Steel Assembly | RIGID_FRAME | 3РС7-4
Steel Assembly | RIGID_FRAME | 3РС7-5
11 x Steel Assembly | RIGID_FRAME | 4РС7-1
Steel Assembly | RIGID_FRAME | 4РС7-2
Steel Assembly | RIGID_FRAME | 4РС9-1
Steel Assembly | RIGID_FRAME | 4РС8-1
Steel Assembly | RIGID_FRAME | 4СГ1-10
Steel Assembly | RIGID_FRAME | 4Б1-8
Steel Assembly | RIGID_FRAME | 4Б3-1
Steel Assembly | RIGID_FRAME | 4Б7-27
Steel Assembly | RIGID_FRAME | 3Б7-25
2 x Steel Assembly | RIGID_FRAME | 2Б7-24
Steel Assembly | RIGID_FRAME | 4СГ1-2
Steel Assembly | RIGID_FRAME | 4СГ1-4
Steel Assembly | RIGID_FRAME | 4СГ1-3
25 x Steel Assembly | RIGID_FRAME | 4СГ1-1
Steel Assembly | RIGID_FRAME | 4СГ1-7
Steel Assembly | RIGID_FRAME | 4СГ1-5
Steel Assembly | RIGID_FRAME | 4СГ1-9
Steel Assembly | RIGID_FRAME | 4СГ1-8
Steel Assembly | RIGID_FRAME | 4СГ1-6
Steel Assembly | RIGID_FRAME | 4Б2-2
Steel Assembly | RIGID_FRAME | 4Б5-4
Steel Assembly | RIGID_FRAME | 4Б5-3
Steel Assembly | RIGID_FRAME | 3СГ1-6
17 x Steel Assembly | RIGID_FRAME | 3СГ1-3
Steel Assembly | RIGID_FRAME | 3СГ1-4
Steel Assembly | RIGID_FRAME | 3СГ1-5
Steel Assembly | RIGID_FRAME | 3Б2-2
Steel Assembly | RIGID_FRAME | 3СГ1-7
Steel Assembly | RIGID_FRAME | 3СГ1-10
2 x Steel Assembly | RIGID_FRAME | 3СГ1-8
Steel Assembly | RIGID_FRAME | 3СГ1-9
Steel Assembly | RIGID_FRAME | 4Б1-7
Steel Assembly | RIGID_FRAME | 4Б1-6
Steel Assembly | RIGID_FRAME | 4Б1-5
Steel Assembly | RIGID_FRAME | 4Б1-4
3 x Steel Assembly | RIGID_FRAME | 4Б1-2
2 x Steel Assembly | RIGID_FRAME | 4Б1-3
Steel Assembly | RIGID_FRAME | 4Б1-1
Steel Assembly | RIGID_FRAME | 3Б1-9
3 x Steel Assembly | RIGID_FRAME | 3Б1-7
2 x Steel Assembly | RIGID_FRAME | 3Б1-8
Steel Assembly | RIGID_FRAME | 3Б1-6
4 x Steel Assembly | RIGID_FRAME | 3СГ1-2
Steel Assembly | RIGID_FRAME | 3Б1-5
Steel Assembly | RIGID_FRAME | 3Б1-4
2 x Steel Assembly | RIGID_FRAME | 2СГ1-2
2 x Steel Assembly | RIGID_FRAME | 2СГ1-4
2 x Steel Assembly | RIGID_FRAME | 2СГ1-3
2 x Steel Assembly | RIGID_FRAME | 2СГ1-5
2 x Steel Assembly | RIGID_FRAME | 2СГ1-9
4 x Steel Assembly | RIGID_FRAME | 2СГ1-7
2 x Steel Assembly | RIGID_FRAME | 2СГ1-6
2 x Steel Assembly | RIGID_FRAME | 2СГ1-8
2 x Steel Assembly | RIGID_FRAME | 2Б2-2
8 x Steel Assembly | RIGID_FRAME | 3СГ1-1
2 x Steel Assembly | RIGID_FRAME | 3Б1-2
Steel Assembly | RIGID_FRAME | 3Б1-3
Steel Assembly | RIGID_FRAME | 3Б1-1
56 x Steel Assembly | RIGID_FRAME | 2СГ1-1
2 x Steel Assembly | RIGID_FRAME | 2Б1-6
8 x Steel Assembly | RIGID_FRAME | 2Б1-3
2 x Steel Assembly | RIGID_FRAME | 2Б1-5
2 x Steel Assembly | RIGID_FRAME | 2Б1-1
Steel Assembly | RIGID_FRAME | 2Б1-4
12 x Steel Assembly | RIGID_FRAME | 1СГ1-15
Steel Assembly | RIGID_FRAME | 1Б1-6
3 x Steel Assembly | RIGID_FRAME | 1Б1-4
2 x Steel Assembly | RIGID_FRAME | 1Б1-5
2 x Steel Assembly | RIGID_FRAME | 1СГ1-10
Steel Assembly | RIGID_FRAME | 1Б1-3
Steel Assembly | RIGID_FRAME | 1Б2-1
2 x Steel Assembly | RIGID_FRAME | 1СГ1-1
Steel Assembly | RIGID_FRAME | 1Б3-1
Steel Assembly | RIGID_FRAME | 1Б6-1
Steel Assembly | RIGID_FRAME | 1Б5-4
Steel Assembly | RIGID_FRAME | 1Б5-3
Steel Assembly | RIGID_FRAME | 1Б5-2
3 x Steel Assembly | RIGID_FRAME | 1СГ1-2
Steel Assembly | RIGID_FRAME | 1Б3-2
Steel Assembly | RIGID_FRAME | 1Б3-3
4 x Steel Assembly | RIGID_FRAME | 1СГ1-3
Steel Assembly | RIGID_FRAME | 1Б3-4
Steel Assembly | RIGID_FRAME | 1Б5-6
Steel Assembly | RIGID_FRAME | 1Б3-5
Steel Assembly | RIGID_FRAME | 1Б5-8
4 x Steel Assembly | RIGID_FRAME | 1СГ1-4
Steel Assembly | RIGID_FRAME | 1Б1-1
Steel Assembly | RIGID_FRAME | 1Б5-10
Steel Assembly | RIGID_FRAME | 1Б1-2
Steel Assembly | RIGID_FRAME | 1Б5-12
2 x Steel Assembly | RIGID_FRAME | 1СГ1-5
Steel Assembly | RIGID_FRAME | 1Б5-14
Steel Assembly | RIGID_FRAME | 1СГ1-6
Steel Assembly | RIGID_FRAME | 1СГ1-14
Steel Assembly | RIGID_FRAME | 1Б7-6
Steel Assembly | RIGID_FRAME | 1СГ1-8
2 x Steel Assembly | RIGID_FRAME | 1СГ1-12
Steel Assembly | RIGID_FRAME | 1СГ1-7
Steel Assembly | RIGID_FRAME | 1СГ1-13
Steel Assembly | RIGID_FRAME | 1Б6-2
Steel Assembly | RIGID_FRAME | 1СГ1-9
Steel Assembly | RIGID_FRAME | 1СГ1-11
2 x Steel Assembly | RIGID_FRAME | 1Б7-3
Steel Assembly | RIGID_FRAME | 1Б7-8
2 x Steel Assembly | RIGID_FRAME | 1Б7-11
Steel Assembly | RIGID_FRAME | 1Б7-10
Steel Assembly | RIGID_FRAME | 1Б7-7
Steel Assembly | RIGID_FRAME | 1Б7-4
3 x Steel Assembly | RIGID_FRAME | 1Б7-12
Steel Assembly | RIGID_FRAME | 1Б7-15
3 x Steel Assembly | RIGID_FRAME | 1Б7-23
Steel Assembly | RIGID_FRAME | 1Б7-22
4 x Steel Assembly | RIGID_FRAME | 1Б7-19
Steel Assembly | RIGID_FRAME | 1Б7-18
Steel Assembly | RIGID_FRAME | 1Б7-21
Steel Assembly | RIGID_FRAME | 1Б7-14
Steel Assembly | RIGID_FRAME | 1Б7-20
Steel Assembly | RIGID_FRAME | 1Б7-13
Steel Assembly | RIGID_FRAME | 1Б7-17
Steel Assembly | RIGID_FRAME | 1Б5-5
Steel Assembly | RIGID_FRAME | 1Б7-1
2 x Steel Assembly | RIGID_FRAME | 1Б6-3
Steel Assembly | RIGID_FRAME | 1Б5-1
Steel Assembly | RIGID_FRAME | 1Б5-7
Steel Assembly | RIGID_FRAME | 1Б5-9
Steel Assembly | RIGID_FRAME | 1Б7-25
7 x Steel Assembly | RIGID_FRAME | 1Б7-2
10 x Steel Assembly | RIGID_FRAME | 1Б7-16
6 x Steel Assembly | RIGID_FRAME | 1Б7-26
5 x Steel Assembly | RIGID_FRAME | 1Б7-9
100 x Steel Assembly | RIGID_FRAME | 4Н2-2
100 x Steel Assembly | RIGID_FRAME | 4Н2-1
112 x Steel Assembly | RIGID_FRAME | 3Н2-2
112 x Steel Assembly | RIGID_FRAME | 3Н2-1
230 x Steel Assembly | RIGID_FRAME | 2Н2-2
230 x Steel Assembly | RIGID_FRAME | 2Н2-1
111 x Steel Assembly | RIGID_FRAME | 1Н2-2
111 x Steel Assembly | RIGID_FRAME | 1Н2-1
Steel Assembly | RIGID_FRAME | 1Б7-5
2 x Steel Assembly | RIGID_FRAME | 2Б7-23
Steel Assembly | RIGID_FRAME | 3Б7-24
19 x Steel Assembly | RIGID_FRAME | 2Б7-9
3 x Steel Assembly | RIGID_FRAME | 2Б7-15
3 x Steel Assembly | RIGID_FRAME | 2Б7-12
3 x Steel Assembly | RIGID_FRAME | 2Б7-4
3 x Steel Assembly | RIGID_FRAME | 2Б7-6
Steel Assembly | RIGID_FRAME | 2Б7-10
4 x Steel Assembly | RIGID_FRAME | 2Б7-13
4 x Steel Assembly | RIGID_FRAME | 2Б7-7
4 x Steel Assembly | RIGID_FRAME | 2Б7-22
4 x Steel Assembly | RIGID_FRAME | 2Б7-18
2 x Steel Assembly | RIGID_FRAME | 2Б7-21
4 x Steel Assembly | RIGID_FRAME | 2Б7-14
4 x Steel Assembly | RIGID_FRAME | 2Б7-8
2 x Steel Assembly | RIGID_FRAME | 2Б7-5
2 x Steel Assembly | RIGID_FRAME | 2Б7-19
9 x Steel Assembly | RIGID_FRAME | 3Б7-9
2 x Steel Assembly | RIGID_FRAME | 3Б7-8
2 x Steel Assembly | RIGID_FRAME | 3Б7-12
2 x Steel Assembly | RIGID_FRAME | 3Б7-7
2 x Steel Assembly | RIGID_FRAME | 3Б7-11
Steel Assembly | RIGID_FRAME | 3Б7-17
Steel Assembly | RIGID_FRAME | 3Б7-21
9 x Steel Assembly | RIGID_FRAME | 4Б7-8
Steel Assembly | RIGID_FRAME | 4Б7-16
Steel Assembly | RIGID_FRAME | 4Б7-21
Steel Assembly | RIGID_FRAME | 4Б7-7
Steel Assembly | RIGID_FRAME | 4Б7-11
Steel Assembly | RIGID_FRAME | 4Б7-6
Steel Assembly | RIGID_FRAME | 4Б7-10
Steel Assembly | RIGID_FRAME | 4Б7-18
Steel Assembly | RIGID_FRAME | 4Б7-23
Steel Assembly | RIGID_FRAME | 4Б7-17
Steel Assembly | RIGID_FRAME | 4Б7-22
2 x Steel Assembly | RIGID_FRAME | 3Б7-23
2 x Steel Assembly | RIGID_FRAME | 3Б7-16
Steel Assembly | RIGID_FRAME | 3Б7-22
Steel Assembly | RIGID_FRAME | 3Б7-6
Steel Assembly | RIGID_FRAME | 3Б7-13
Steel Assembly | RIGID_FRAME | 3Б7-5
Steel Assembly | RIGID_FRAME | 3Б7-18
Steel Assembly | RIGID_FRAME | 4Б7-26
50 x Steel Assembly | RIGID_FRAME | 3Б7-19
7 x Steel Assembly | RIGID_FRAME | 4Б7-2
Steel Assembly | RIGID_FRAME | 4Б7-1
7 x Steel Assembly | RIGID_FRAME | 3Б7-2
Steel Assembly | RIGID_FRAME | 3Б7-1
14 x Steel Assembly | RIGID_FRAME | 2Б7-2
2 x Steel Assembly | RIGID_FRAME | 2Б7-1
75 x Steel Assembly | RIGID_FRAME | 4Б7-3
28 x Steel Assembly | RIGID_FRAME | 3Б7-3
Steel Assembly | RIGID_FRAME | 4Б7-5
Steel Assembly | RIGID_FRAME | 4Б7-12
Steel Assembly | RIGID_FRAME | 4Б7-4
Steel Assembly | RIGID_FRAME | 4Б7-24
2 x Steel Assembly | RIGID_FRAME | 4Б7-25
Steel Assembly | RIGID_FRAME | 4Б7-19
2 x Steel Assembly | RIGID_FRAME | 4Б7-15
Steel Assembly | RIGID_FRAME | 4Б5-1
2 x Steel Assembly | RIGID_FRAME | 4Б7-38
2 x Steel Assembly | RIGID_FRAME | 4Б7-36
2 x Steel Assembly | RIGID_FRAME | 4Б7-28
2 x Steel Assembly | RIGID_FRAME | 4Б7-30
4 x Steel Assembly | RIGID_FRAME | 4Б5-6
Steel Assembly | RIGID_FRAME | 4Б7-39
3 x Steel Assembly | RIGID_FRAME | 4Б7-34
2 x Steel Assembly | RIGID_FRAME | 4Б7-35
4 x Steel Assembly | RIGID_FRAME | 4Б5-5
11 x Steel Assembly | RIGID_FRAME | 3Б7-4
49 x Steel Assembly | RIGID_FRAME | 1Б7-27
13 x Steel Assembly | RIGID_FRAME | 1Б7-24
Steel Assembly | RIGID_FRAME | 1Б5-13
Steel Assembly | RIGID_FRAME | 1Б5-11
2 x Steel Assembly | RIGID_FRAME | 4ОГ5-2
50 x Steel Assembly | RIGID_FRAME | 4ОГ5-1
56 x Steel Assembly | RIGID_FRAME | 3ОГ5-1
114 x Steel Assembly | RIGID_FRAME | 2ОГ5-1
56 x Steel Assembly | RIGID_FRAME | 1ОГ5-1
5 x Steel Assembly | RIGID_FRAME | 4Б13-21
Steel Assembly | RIGID_FRAME | 4Б13-20
Steel Assembly | RIGID_FRAME | 4П2-9
Steel Assembly | RIGID_FRAME | 4П2-8
5 x Steel Assembly | RIGID_FRAME | 4П2-10
6 x Steel Assembly | RIGID_FRAME | 1Б13-3
Steel Assembly | RIGID_FRAME | 1Б13-2
Steel Assembly | RIGID_FRAME | 1Б13-1
Steel Assembly | RIGID_FRAME | 1П1-3
6 x Steel Assembly | RIGID_FRAME | 1П1-4
Steel Assembly | RIGID_FRAME | 1П1-2
Steel Assembly | RIGID_FRAME | 1П1-1
Steel Assembly | RIGID_FRAME | 4СФ3-10
Steel Assembly | RIGID_FRAME | 4СФ3-12
2 x Steel Assembly | RIGID_FRAME | 4СФ3-11
2 x Steel Assembly | RIGID_FRAME | 4РФ1-11
3 x Steel Assembly | RIGID_FRAME | 4РФ1-17
Steel Assembly | RIGID_FRAME | 4РФ1-18
Steel Assembly | RIGID_FRAME | 4РФ1-16
Steel Assembly | RIGID_FRAME | 4К3-2
4 x Steel Assembly | RIGID_FRAME | 2СВ5-2
4 x Steel Assembly | RIGID_FRAME | 2СВ5-1
2 x Steel Assembly | RIGID_FRAME | 2К4-9
2 x Steel Assembly | RIGID_FRAME | 2К4-10
2 x Steel Assembly | RIGID_FRAME | 2К4-7
2 x Steel Assembly | RIGID_FRAME | 2К4-8
2 x Steel Assembly | RIGID_FRAME | 2К4-5
2 x Steel Assembly | RIGID_FRAME | 2К4-6
2 x Steel Assembly | RIGID_FRAME | 4СВ5-2
2 x Steel Assembly | RIGID_FRAME | 4СВ5-1
Steel Assembly | RIGID_FRAME | 4К4-9
Steel Assembly | RIGID_FRAME | 4К4-10
Steel Assembly | RIGID_FRAME | 4К4-7
Steel Assembly | RIGID_FRAME | 4К4-8
Steel Assembly | RIGID_FRAME | 4К4-5
Steel Assembly | RIGID_FRAME | 4К4-6
2 x Steel Assembly | RIGID_FRAME | 3СВ5-2
2 x Steel Assembly | RIGID_FRAME | 3СВ5-1
Steel Assembly | RIGID_FRAME | 3К4-9
Steel Assembly | RIGID_FRAME | 3К4-10
Steel Assembly | RIGID_FRAME | 3К4-7
Steel Assembly | RIGID_FRAME | 3К4-8
Steel Assembly | RIGID_FRAME | 3К4-5
Steel Assembly | RIGID_FRAME | 3К4-6
Steel Assembly | RIGID_FRAME | 1К4-7
Steel Assembly | RIGID_FRAME | 1К4-3
Steel Assembly | RIGID_FRAME | 1К4-5
2 x Steel Assembly | RIGID_FRAME | 1СВ5-3
2 x Steel Assembly | RIGID_FRAME | 1СВ5-2
Steel Assembly | RIGID_FRAME | 1К4-8
Steel Assembly | RIGID_FRAME | 1К4-6
Steel Assembly | RIGID_FRAME | 1К4-4
Steel Assembly | RIGID_FRAME | 1СВ4-2
Steel Assembly | RIGID_FRAME | 1СВ4-1
Steel Assembly | RIGID_FRAME | 1К3-7
Steel Assembly | RIGID_FRAME | 1К3-9
Steel Assembly | RIGID_FRAME | 1СВ4-3
Steel Assembly | RIGID_FRAME | 4РФ1-3
Steel Assembly | RIGID_FRAME | 4РС11-1
Steel Assembly | RIGID_FRAME | 3РФ1-21
Steel Assembly | RIGID_FRAME | 3РС11-5
Steel Assembly | RIGID_FRAME | 4К4-1
2 x Steel Assembly | RIGID_FRAME | 3К4-1
2 x Steel Assembly | RIGID_FRAME | 2СФ1-2
Steel Assembly | RIGID_FRAME | 3РФ1-3
2 x Steel Assembly | RIGID_FRAME | 2РФ1-11
Steel Assembly | RIGID_FRAME | 3РС11-1
2 x Steel Assembly | RIGID_FRAME | 2РС11-3
4 x Steel Assembly | RIGID_FRAME | 2К4-1
2 x Steel Assembly | RIGID_FRAME | 2СФ1-1
2 x Steel Assembly | RIGID_FRAME | 2РФ1-3
2 x Steel Assembly | RIGID_FRAME | 2РС11-1
Steel Assembly | RIGID_FRAME | 1СФ1-1
Steel Assembly | RIGID_FRAME | 1РФ1-24
Steel Assembly | RIGID_FRAME | 1РС11-4
14 x Steel Assembly | RIGID_FRAME | 1РФ1-16
56 x Steel Assembly | RIGID_FRAME | 2РФ1-6
8 x Steel Assembly | RIGID_FRAME | 3РФ1-6
16 x Steel Assembly | RIGID_FRAME | 3РФ1-18
24 x Steel Assembly | RIGID_FRAME | 4РФ1-6
Steel Assembly | RIGID_FRAME | 4РС11-3
11 x Steel Assembly | RIGID_FRAME | 4РС11-2
7 x Steel Assembly | RIGID_FRAME | 3РС11-4
3 x Steel Assembly | RIGID_FRAME | 3РС11-2
24 x Steel Assembly | RIGID_FRAME | 2РС11-2
6 x Steel Assembly | RIGID_FRAME | 1РС11-2
Steel Assembly | RIGID_FRAME | 1К4-9
2 x Steel Assembly | RIGID_FRAME | 1РС11-3
Steel Assembly | RIGID_FRAME | 1РС11-1
4 x Steel Assembly | RIGID_FRAME | 1РФ1-20
4 x Steel Assembly | RIGID_FRAME | 3РФ1-13
9 x Steel Assembly | RIGID_FRAME | 4К4-3
10 x Steel Assembly | RIGID_FRAME | 3К4-3
20 x Steel Assembly | RIGID_FRAME | 2К4-3
6 x Steel Assembly | RIGID_FRAME | 1К4-1
Steel Assembly | RIGID_FRAME | 4РС10-13
Steel Assembly | RIGID_FRAME | 4РФ1-10
Steel Assembly | RIGID_FRAME | 4РС10-12
Steel Assembly | RIGID_FRAME | 4РС10-11
Steel Assembly | RIGID_FRAME | 4РС10-10
Steel Assembly | RIGID_FRAME | 4РС10-9
Steel Assembly | RIGID_FRAME | 4РС10-8
Steel Assembly | RIGID_FRAME | 4РС10-7
Steel Assembly | RIGID_FRAME | 4РС10-6
Steel Assembly | RIGID_FRAME | 4РС10-5
Steel Assembly | RIGID_FRAME | 4РС10-4
Steel Assembly | RIGID_FRAME | 4РС10-3
Steel Assembly | RIGID_FRAME | 4РС10-2
Steel Assembly | RIGID_FRAME | 4РС10-1
Steel Assembly | RIGID_FRAME | 3РС10-14
Steel Assembly | RIGID_FRAME | 3РС10-13
Steel Assembly | RIGID_FRAME | 3РС10-12
Steel Assembly | RIGID_FRAME | 3РС10-11
Steel Assembly | RIGID_FRAME | 3РС10-10
Steel Assembly | RIGID_FRAME | 3РС10-9
Steel Assembly | RIGID_FRAME | 3РС10-8
Steel Assembly | RIGID_FRAME | 3РС10-7
Steel Assembly | RIGID_FRAME | 3РС10-6
Steel Assembly | RIGID_FRAME | 3РС10-5
Steel Assembly | RIGID_FRAME | 3РС10-4
Steel Assembly | RIGID_FRAME | 3РС10-3
Steel Assembly | RIGID_FRAME | 3РС10-2
Steel Assembly | RIGID_FRAME | 3РС10-1
Steel Assembly | RIGID_FRAME | 2РС10-28
Steel Assembly | RIGID_FRAME | 2РС10-27
Steel Assembly | RIGID_FRAME | 2РС10-26
Steel Assembly | RIGID_FRAME | 2РС10-25
Steel Assembly | RIGID_FRAME | 2РС10-24
Steel Assembly | RIGID_FRAME | 2РС10-23
Steel Assembly | RIGID_FRAME | 2РС10-22
Steel Assembly | RIGID_FRAME | 2РС10-21
Steel Assembly | RIGID_FRAME | 2РС10-20
Steel Assembly | RIGID_FRAME | 2РС10-19
Steel Assembly | RIGID_FRAME | 2РС10-18
Steel Assembly | RIGID_FRAME | 2РС10-17
Steel Assembly | RIGID_FRAME | 2РС10-16
Steel Assembly | RIGID_FRAME | 2РС10-15
Steel Assembly | RIGID_FRAME | 2РС10-14
Steel Assembly | RIGID_FRAME | 2РС10-13
Steel Assembly | RIGID_FRAME | 2РС10-12
Steel Assembly | RIGID_FRAME | 2РС10-11
Steel Assembly | RIGID_FRAME | 2РС10-10
Steel Assembly | RIGID_FRAME | 2РС10-9
Steel Assembly | RIGID_FRAME | 2РС10-8
Steel Assembly | RIGID_FRAME | 2РС10-7
Steel Assembly | RIGID_FRAME | 2РС10-6
Steel Assembly | RIGID_FRAME | 2РС10-5
Steel Assembly | RIGID_FRAME | 2РС10-4
Steel Assembly | RIGID_FRAME | 2РС10-3
Steel Assembly | RIGID_FRAME | 2РС10-2
Steel Assembly | RIGID_FRAME | 2РС10-1
Steel Assembly | RIGID_FRAME | 1РС10-1
Steel Assembly | RIGID_FRAME | 1РС10-2
Steel Assembly | RIGID_FRAME | 1РС10-3
Steel Assembly | RIGID_FRAME | 1РС10-4
Steel Assembly | RIGID_FRAME | 1РС10-5
Steel Assembly | RIGID_FRAME | 1РС10-6
Steel Assembly | RIGID_FRAME | 1РС10-7
Steel Assembly | RIGID_FRAME | 1РС10-8
Steel Assembly | RIGID_FRAME | 1РС10-9
Steel Assembly | RIGID_FRAME | 1РС10-10
8 x Steel Assembly | RIGID_FRAME | 1РФ1-13
28 x Steel Assembly | RIGID_FRAME | 2РФ1-7
4 x Steel Assembly | RIGID_FRAME | 3РФ1-7
8 x Steel Assembly | RIGID_FRAME | 3РФ1-19
12 x Steel Assembly | RIGID_FRAME | 4РФ1-7
Steel Assembly | RIGID_FRAME | 4К4-2
Steel Assembly | RIGID_FRAME | 4РС12-1
26 x Steel Assembly | RIGID_FRAME | 4ПП-1
2 x Steel Assembly | RIGID_FRAME | 2РС12-3
Steel Assembly | RIGID_FRAME | 3РС12-5
Steel Assembly | RIGID_FRAME | 3К4-11
28 x Steel Assembly | RIGID_FRAME | 3ПП-1
Steel Assembly | RIGID_FRAME | 3РС12-1
Steel Assembly | RIGID_FRAME | 3К4-2
2 x Steel Assembly | RIGID_FRAME | 2К4-11
56 x Steel Assembly | RIGID_FRAME | 2ПП-1
2 x Steel Assembly | RIGID_FRAME | 2РС12-1
2 x Steel Assembly | RIGID_FRAME | 2К4-2
Steel Assembly | RIGID_FRAME | 1К4-10
Steel Assembly | RIGID_FRAME | 1РС12-3
Steel Assembly | RIGID_FRAME | 4РС12-3
7 x Steel Assembly | RIGID_FRAME | 1РС12-1
20 x Steel Assembly | RIGID_FRAME | 1ПП-3
Steel Assembly | RIGID_FRAME | 1РФ1-12
2 x Steel Assembly | RIGID_FRAME | 1РФ1-21
2 x Steel Assembly | RIGID_FRAME | 3РФ1-14
11 x Steel Assembly | RIGID_FRAME | 4РС12-2
7 x Steel Assembly | RIGID_FRAME | 3РС12-4
2 x Steel Assembly | RIGID_FRAME | 3РС12-3
3 x Steel Assembly | RIGID_FRAME | 3РС12-2
24 x Steel Assembly | RIGID_FRAME | 2РС12-2
2 x Steel Assembly | RIGID_FRAME | 1РС12-2
6 x Steel Assembly | RIGID_FRAME | 1РФ1-9
5 x Steel Assembly | RIGID_FRAME | 1РС1-1
5 x Steel Assembly | RIGID_FRAME | 1РС1-2
8 x Steel Assembly | RIGID_FRAME | 1РС1-3
2 x Steel Assembly | RIGID_FRAME | 1РС1-4
6 x Steel Assembly | RIGID_FRAME | 1РФ1-2
Steel Assembly | RIGID_FRAME | 1К3-2
Steel Assembly | RIGID_FRAME | 1К3-4
Steel Assembly | RIGID_FRAME | 1К3-6
2 x Steel Assembly | RIGID_FRAME | 1РФ1-1
2 x Steel Assembly | RIGID_FRAME | 1РФ1-3
3 x Steel Assembly | RIGID_FRAME | 1РФ1-5
3 x Steel Assembly | RIGID_FRAME | 1РФ1-7
2 x Steel Assembly | RIGID_FRAME | 1РФ1-4
2 x Steel Assembly | RIGID_FRAME | 1РФ1-6
4 x Steel Assembly | RIGID_FRAME | 1РФ1-8
Steel Assembly | RIGID_FRAME | 1СФ3-5
Steel Assembly | RIGID_FRAME | 1СФ3-8
Steel Assembly | RIGID_FRAME | 1СФ3-7
Steel Assembly | RIGID_FRAME | 1СФ3-6
3 x Steel Assembly | RIGID_FRAME | 4РФ1-14
Steel Assembly | RIGID_FRAME | 4К3-1
Steel Assembly | RIGID_FRAME | 4РФ1-13
Steel Assembly | RIGID_FRAME | 4РФ1-15
4 x Steel Assembly | RIGID_FRAME | 4РФ1-2
Steel Assembly | RIGID_FRAME | 4РФ1-1
Steel Assembly | RIGID_FRAME | 4К2-1
Steel Assembly | RIGID_FRAME | 4Б8-1
Steel Assembly | RIGID_FRAME | 4СФ3-1
Steel Assembly | RIGID_FRAME | 4СФ3-4
13 x Steel Assembly | RIGID_FRAME | 4СФ3-3
Steel Assembly | RIGID_FRAME | 4СФ3-2
4 x Steel Assembly | RIGID_FRAME | 3РФ1-22
Steel Assembly | RIGID_FRAME | 3РФ1-23
Steel Assembly | RIGID_FRAME | 3К2-6
Steel Assembly | RIGID_FRAME | 3Б8-7
2 x Steel Assembly | RIGID_FRAME | 3СФ3-1
2 x Steel Assembly | RIGID_FRAME | 3СФ3-4
14 x Steel Assembly | RIGID_FRAME | 3СФ3-3
2 x Steel Assembly | RIGID_FRAME | 3СФ3-2
8 x Steel Assembly | RIGID_FRAME | 2РФ1-12
4 x Steel Assembly | RIGID_FRAME | 2РФ1-1
4 x Steel Assembly | RIGID_FRAME | 3РФ1-2
Steel Assembly | RIGID_FRAME | 3РФ1-1
2 x Steel Assembly | RIGID_FRAME | 2К2-6
2 x Steel Assembly | RIGID_FRAME | 2Б8-7
Steel Assembly | RIGID_FRAME | 3К2-1
Steel Assembly | RIGID_FRAME | 3Б8-1
4 x Steel Assembly | RIGID_FRAME | 2СФ3-1
4 x Steel Assembly | RIGID_FRAME | 2СФ3-4
28 x Steel Assembly | RIGID_FRAME | 2СФ3-3
4 x Steel Assembly | RIGID_FRAME | 2СФ3-2
8 x Steel Assembly | RIGID_FRAME | 2РФ1-2
2 x Steel Assembly | RIGID_FRAME | 2К2-1
2 x Steel Assembly | RIGID_FRAME | 2Б8-1
Steel Assembly | RIGID_FRAME | 1РФ1-26
4 x Steel Assembly | RIGID_FRAME | 1РФ1-25
Steel Assembly | RIGID_FRAME | 1К2-4
Steel Assembly | RIGID_FRAME | 1Б8-6
Steel Assembly | RIGID_FRAME | 1СФ3-11
2 x Steel Assembly | RIGID_FRAME | 1СФ3-4
14 x Steel Assembly | RIGID_FRAME | 1СФ3-3
2 x Steel Assembly | RIGID_FRAME | 1СФ3-2
14 x Steel Assembly | RIGID_FRAME | 2РФ1-4
Steel Assembly | RIGID_FRAME | 1СФ3-1
Steel Assembly | RIGID_FRAME | 1К3-1
12 x Steel Assembly | RIGID_FRAME | 4СФ2-1
18 x Steel Assembly | RIGID_FRAME | 4РФ3-1
12 x Steel Assembly | RIGID_FRAME | 4СФ3-6
12 x Steel Assembly | RIGID_FRAME | 4СФ3-5
12 x Steel Assembly | RIGID_FRAME | 3СФ2-1
18 x Steel Assembly | RIGID_FRAME | 3РФ3-1
12 x Steel Assembly | RIGID_FRAME | 3СФ3-6
12 x Steel Assembly | RIGID_FRAME | 3СФ3-5
24 x Steel Assembly | RIGID_FRAME | 2СФ2-1
36 x Steel Assembly | RIGID_FRAME | 2РФ3-1
24 x Steel Assembly | RIGID_FRAME | 2СФ3-6
24 x Steel Assembly | RIGID_FRAME | 2СФ3-5
12 x Steel Assembly | RIGID_FRAME | 1СФ2-1
18 x Steel Assembly | RIGID_FRAME | 1РФ3-1
12 x Steel Assembly | RIGID_FRAME | 1СФ3-10
12 x Steel Assembly | RIGID_FRAME | 1СФ3-9
2 x Steel Assembly | RIGID_FRAME | 2СВ4-1
4 x Steel Assembly | RIGID_FRAME | 2СВ4-3
2 x Steel Assembly | RIGID_FRAME | 2СВ4-2
2 x Steel Assembly | RIGID_FRAME | 2К2-5
2 x Steel Assembly | RIGID_FRAME | 2Б8-6
2 x Steel Assembly | RIGID_FRAME | 2Б8-4
Steel Assembly | RIGID_FRAME | 4СВ4-3
2 x Steel Assembly | RIGID_FRAME | 4СВ4-2
Steel Assembly | RIGID_FRAME | 4СВ4-1
Steel Assembly | RIGID_FRAME | 4К2-3
Steel Assembly | RIGID_FRAME | 4Б8-5
Steel Assembly | RIGID_FRAME | 4Б8-3
Steel Assembly | RIGID_FRAME | 3СВ4-3
2 x Steel Assembly | RIGID_FRAME | 3СВ4-2
Steel Assembly | RIGID_FRAME | 3К2-5
Steel Assembly | RIGID_FRAME | 3Б8-6
Steel Assembly | RIGID_FRAME | 3СВ4-1
Steel Assembly | RIGID_FRAME | 3Б8-4
Steel Assembly | RIGID_FRAME | 1СВ4-6
2 x Steel Assembly | RIGID_FRAME | 1СВ4-5
Steel Assembly | RIGID_FRAME | 1К2-3
Steel Assembly | RIGID_FRAME | 1Б8-4
Steel Assembly | RIGID_FRAME | 1СВ4-4
Steel Assembly | RIGID_FRAME | 1Б8-2
2 x Steel Assembly | RIGID_FRAME | 4РС2-2
2 x Steel Assembly | RIGID_FRAME | 1РС1-5
24 x Steel Assembly | RIGID_FRAME | 4РС2-1
16 x Steel Assembly | RIGID_FRAME | 3РС2-4
4 x Steel Assembly | RIGID_FRAME | 3РС2-3
4 x Steel Assembly | RIGID_FRAME | 1РС2-2
14 x Steel Assembly | RIGID_FRAME | 1РС2-1
7 x Steel Assembly | RIGID_FRAME | 3РС2-1
55 x Steel Assembly | RIGID_FRAME | 2РС2-1
Steel Assembly | RIGID_FRAME | 1К3-3
2 x Steel Assembly | RIGID_FRAME | 1К3-5
Steel Assembly | RIGID_FRAME | 1К3-8
Steel Assembly | RIGID_FRAME | 4Б8-6
Steel Assembly | RIGID_FRAME | 4К2-4
8 x Steel Assembly | RIGID_FRAME | 4Б8-2
10 x Steel Assembly | RIGID_FRAME | 4К2-2
Steel Assembly | RIGID_FRAME | 4Б8-4
9 x Steel Assembly | RIGID_FRAME | 3Б8-2
10 x Steel Assembly | RIGID_FRAME | 3К2-2
Steel Assembly | RIGID_FRAME | 3Б8-5
19 x Steel Assembly | RIGID_FRAME | 2Б8-2
20 x Steel Assembly | RIGID_FRAME | 2К2-2
2 x Steel Assembly | RIGID_FRAME | 2Б8-5
Steel Assembly | RIGID_FRAME | 2К2-8
Steel Assembly | RIGID_FRAME | 2К2-7
5 x Steel Assembly | RIGID_FRAME | 1Б8-5
7 x Steel Assembly | RIGID_FRAME | 1К2-2
Steel Assembly | RIGID_FRAME | 1Б8-3
Steel Assembly | RIGID_FRAME | 1Б8-1
Steel Assembly | RIGID_FRAME | 1К2-1
2 x Steel Assembly | RIGID_FRAME | 4РФ1-9
Steel Assembly | RIGID_FRAME | 4РФ1-12
24 x Steel Assembly | RIGID_FRAME | 4РФ1-5
6 x Steel Assembly | RIGID_FRAME | 4РФ1-8
6 x Steel Assembly | RIGID_FRAME | 4РФ1-4
16 x Steel Assembly | RIGID_FRAME | 3РФ1-17
4 x Steel Assembly | RIGID_FRAME | 3РФ1-20
4 x Steel Assembly | RIGID_FRAME | 3РФ1-16
4 x Steel Assembly | RIGID_FRAME | 3РФ1-12
Steel Assembly | RIGID_FRAME | 3РФ1-15
Steel Assembly | RIGID_FRAME | 3РФ1-11
2 x Steel Assembly | RIGID_FRAME | 3РФ1-8
6 x Steel Assembly | RIGID_FRAME | 3РФ1-5
2 x Steel Assembly | RIGID_FRAME | 3РФ1-4
54 x Steel Assembly | RIGID_FRAME | 2РФ1-5
14 x Steel Assembly | RIGID_FRAME | 2РФ1-8
14 x Steel Assembly | RIGID_FRAME | 1РФ1-15
4 x Steel Assembly | RIGID_FRAME | 1РФ1-17
3 x Steel Assembly | RIGID_FRAME | 1РФ1-23
4 x Steel Assembly | RIGID_FRAME | 1РФ1-19
Steel Assembly | RIGID_FRAME | 1РФ1-22
Steel Assembly | RIGID_FRAME | 1РФ1-18
2 x Steel Assembly | RIGID_FRAME | 1РФ1-14
Steel Assembly | RIGID_FRAME | 1РФ1-10
Steel Assembly | RIGID_FRAME | 4СГ2-3
2 x Steel Assembly | RIGID_FRAME | 4СГ2-1
Steel Assembly | RIGID_FRAME | 4СГ2-2
Steel Assembly | RIGID_FRAME | 3СГ2-3
2 x Steel Assembly | RIGID_FRAME | 3СГ2-1
2 x Steel Assembly | RIGID_FRAME | 2СГ2-3
4 x Steel Assembly | RIGID_FRAME | 2СГ2-1
2 x Steel Assembly | RIGID_FRAME | 2СГ2-2
Steel Assembly | RIGID_FRAME | 1СГ2-3
2 x Steel Assembly | RIGID_FRAME | 1СГ2-1
Steel Assembly | RIGID_FRAME | 3СГ2-2
Steel Assembly | RIGID_FRAME | 1СГ2-2
3 x Steel Assembly | RIGID_FRAME | 1П2-2
4 x Steel Assembly | RIGID_FRAME | 1П2-1
14 x Steel Assembly | RIGID_FRAME | 1П2-3
Steel Assembly | RIGID_FRAME | 1Б9-4
Steel Assembly | RIGID_FRAME | 1П2-4
5 x Steel Assembly | RIGID_FRAME | 1П2-5
Steel Assembly | RIGID_FRAME | 1П2-6
Steel Assembly | RIGID_FRAME | 4К1-21
Steel Assembly | RIGID_FRAME | 4К1-19
Steel Assembly | RIGID_FRAME | 4К1-17
Steel Assembly | RIGID_FRAME | 4К1-15
6 x Steel Assembly | RIGID_FRAME | 4К1-6
6 x Steel Assembly | RIGID_FRAME | 4К1-5
2 x Steel Assembly | RIGID_FRAME | 4К1-4
Steel Assembly | RIGID_FRAME | 4К1-12
Steel Assembly | RIGID_FRAME | 4К1-13
Steel Assembly | RIGID_FRAME | 4К1-11
Steel Assembly | RIGID_FRAME | 4К1-8
Steel Assembly | RIGID_FRAME | 4К1-2
Steel Assembly | RIGID_FRAME | 4К1-3
Steel Assembly | RIGID_FRAME | 4К1-1
2 x Steel Assembly | RIGID_FRAME | 3К1-2
3 x Steel Assembly | RIGID_FRAME | 3К1-4
2 x Steel Assembly | RIGID_FRAME | 3К1-1
2 x Steel Assembly | RIGID_FRAME | 3К1-3
8 x Steel Assembly | RIGID_FRAME | 3К1-6
6 x Steel Assembly | RIGID_FRAME | 3К1-7
Steel Assembly | RIGID_FRAME | 3К1-14
Steel Assembly | RIGID_FRAME | 3К1-15
Steel Assembly | RIGID_FRAME | 3К1-13
Steel Assembly | RIGID_FRAME | 3К1-10
4 x Steel Assembly | RIGID_FRAME | 2К1-2
6 x Steel Assembly | RIGID_FRAME | 2К1-4
4 x Steel Assembly | RIGID_FRAME | 2К1-1
4 x Steel Assembly | RIGID_FRAME | 2К1-3
16 x Steel Assembly | RIGID_FRAME | 2К1-6
14 x Steel Assembly | RIGID_FRAME | 2К1-7
2 x Steel Assembly | RIGID_FRAME | 2К1-14
2 x Steel Assembly | RIGID_FRAME | 2К1-15
2 x Steel Assembly | RIGID_FRAME | 2К1-13
2 x Steel Assembly | RIGID_FRAME | 2К1-10
2 x Steel Assembly | RIGID_FRAME | 1К1-17
2 x Steel Assembly | RIGID_FRAME | 1К1-21
Steel Assembly | RIGID_FRAME | 1К1-9
Steel Assembly | RIGID_FRAME | 1К1-5
4 x Steel Assembly | RIGID_FRAME | 1К1-23
4 x Steel Assembly | RIGID_FRAME | 1К1-22
Steel Assembly | RIGID_FRAME | 1К1-19
Steel Assembly | RIGID_FRAME | 1К1-20
Steel Assembly | RIGID_FRAME | 1К1-18
Steel Assembly | RIGID_FRAME | 1К1-15
Steel Assembly | RIGID_FRAME | 1К1-16
Steel Assembly | RIGID_FRAME | 1К1-14
Steel Assembly | RIGID_FRAME | 1К1-13
Steel Assembly | RIGID_FRAME | 1К1-12
2 x Steel Assembly | RIGID_FRAME | 1К1-11
Steel Assembly | RIGID_FRAME | 1К1-10
Steel Assembly | RIGID_FRAME | 1К1-8
Steel Assembly | RIGID_FRAME | 1К1-6
2 x Steel Assembly | RIGID_FRAME | 1К1-3
Steel Assembly | RIGID_FRAME | 1К1-4
7 x Steel Assembly | RIGID_FRAME | 1ФП1-2
26 x Steel Assembly | RIGID_FRAME | 2ФП1-1
4 x Steel Assembly | RIGID_FRAME | 3ФП1-1
2 x Steel Assembly | RIGID_FRAME | 3ФП3-1
7 x Steel Assembly | RIGID_FRAME | 3ФП2-1
11 x Steel Assembly | RIGID_FRAME | 4ФП2-1
Steel Assembly | RIGID_FRAME | 1ФП4-1
Steel Assembly | RIGID_FRAME | 1ФП1-1
2 x Steel Assembly | RIGID_FRAME | 1РС3-2
4 x Steel Assembly | RIGID_FRAME | 1РС3-4
4 x Steel Assembly | RIGID_FRAME | 2СВ2-2
2 x Steel Assembly | RIGID_FRAME | 2РС6-2
8 x Steel Assembly | RIGID_FRAME | 2СВ2-1
Steel Assembly | RIGID_FRAME | 4РС6-2
2 x Steel Assembly | RIGID_FRAME | 4СВ2-2
4 x Steel Assembly | RIGID_FRAME | 4СВ2-1
2 x Steel Assembly | RIGID_FRAME | 3СВ2-2
Steel Assembly | RIGID_FRAME | 3РС6-2
4 x Steel Assembly | RIGID_FRAME | 3СВ2-1
2 x Steel Assembly | RIGID_FRAME | 1СВ2-2
Steel Assembly | RIGID_FRAME | 1РС6-6
4 x Steel Assembly | RIGID_FRAME | 1СВ2-1
10 x Steel Assembly | RIGID_FRAME | 4РС3-1
2 x Steel Assembly | RIGID_FRAME | 3РС3-2
24 x Steel Assembly | RIGID_FRAME | 2РС3-1
8 x Steel Assembly | RIGID_FRAME | 1РС3-6
6 x Steel Assembly | RIGID_FRAME | 3РС3-3
4 x Steel Assembly | RIGID_FRAME | 3РС3-1
2 x Steel Assembly | RIGID_FRAME | 1РС3-5
2 x Steel Assembly | RIGID_FRAME | 1РС3-3
2 x Steel Assembly | RIGID_FRAME | 4РС3-3
2 x Steel Assembly | RIGID_FRAME | 2РС5-1
16 x Steel Assembly | RIGID_FRAME | 2М-3
4 x Steel Assembly | RIGID_FRAME | 2СВ3-1
Steel Assembly | RIGID_FRAME | 4РС5-1
8 x Steel Assembly | RIGID_FRAME | 4М-3
2 x Steel Assembly | RIGID_FRAME | 4СВ3-1
Steel Assembly | RIGID_FRAME | 3РС5-1
8 x Steel Assembly | RIGID_FRAME | 3М-3
2 x Steel Assembly | RIGID_FRAME | 3СВ3-1
Steel Assembly | RIGID_FRAME | 1РС5-1
8 x Steel Assembly | RIGID_FRAME | 1М-4
2 x Steel Assembly | RIGID_FRAME | 1СВ3-1
Steel Assembly | RIGID_FRAME | 2Б11-1
12 x Steel Assembly | RIGID_FRAME | 4П2-6
66 x Steel Assembly | RIGID_FRAME | 4П2-7
13 x Steel Assembly | RIGID_FRAME | 4А-1
8 x Steel Assembly | RIGID_FRAME | 3П2-11
42 x Steel Assembly | RIGID_FRAME | 3П2-10
15 x Steel Assembly | RIGID_FRAME | 3А-1
28 x Steel Assembly | RIGID_FRAME | 2П2-6
144 x Steel Assembly | RIGID_FRAME | 2П2-7
30 x Steel Assembly | RIGID_FRAME | 2А-1
Steel Assembly | RIGID_FRAME | 1Б11-1
9 x Steel Assembly | RIGID_FRAME | 4К4-4
5 x Steel Assembly | RIGID_FRAME | 4П2-5
Steel Assembly | RIGID_FRAME | 4П2-4
5 x Steel Assembly | RIGID_FRAME | 3П2-13
Steel Assembly | RIGID_FRAME | 3П2-12
10 x Steel Assembly | RIGID_FRAME | 3К4-4
2 x Steel Assembly | RIGID_FRAME | 3П2-9
12 x Steel Assembly | RIGID_FRAME | 3П2-8
4 x Steel Assembly | RIGID_FRAME | 3П2-6
18 x Steel Assembly | RIGID_FRAME | 3П2-7
5 x Steel Assembly | RIGID_FRAME | 3П2-5
Steel Assembly | RIGID_FRAME | 3П2-4
12 x Steel Assembly | RIGID_FRAME | 2П2-4
12 x Steel Assembly | RIGID_FRAME | 2П2-5
20 x Steel Assembly | RIGID_FRAME | 2К4-4
7 x Steel Assembly | RIGID_FRAME | 1П2-8
36 x Steel Assembly | RIGID_FRAME | 1П2-7
5 x Steel Assembly | RIGID_FRAME | 1П2-12
Steel Assembly | RIGID_FRAME | 1П2-11
10 x Steel Assembly | RIGID_FRAME | 1А-1
6 x Steel Assembly | RIGID_FRAME | 1К4-2
2 x Steel Assembly | RIGID_FRAME | 1П2-10
12 x Steel Assembly | RIGID_FRAME | 1П2-9
22 x Steel Assembly | RIGID_FRAME | 4ПП-2
26 x Steel Assembly | RIGID_FRAME | 3ПП-2
18 x Steel Assembly | RIGID_FRAME | 1ПП-2
52 x Steel Assembly | RIGID_FRAME | 2ПП-2
2 x Steel Assembly | RIGID_FRAME | 1Б12-1
10 x Steel Assembly | RIGID_FRAME | 1М-2
2 x Steel Assembly | RIGID_FRAME | 1Б9-3
10 x Steel Assembly | RIGID_FRAME | 1ПП-1
2 x Steel Assembly | RIGID_FRAME | 1СВ1-2
Steel Assembly | RIGID_FRAME | 1Б9-1
Steel Assembly | RIGID_FRAME | 1Б9-2
2 x Steel Assembly | RIGID_FRAME | 1СВ1-1
12 x Steel Assembly | RIGID_FRAME | 1СВ5-1
3 x Steel Assembly | RIGID_FRAME | 1РС3-1
Steel Assembly | RIGID_FRAME | 1РС6-1
144 x Steel Assembly | RIGID_FRAME | 1Ш-1
47 x Steel Assembly | RIGID_FRAME | 1М-1
Steel Assembly | RIGID_FRAME | 1РС6-2
Steel Assembly | RIGID_FRAME | 1РС6-3
4 x Steel Assembly | RIGID_FRAME | 1СВ1-3
Steel Assembly | RIGID_FRAME | 4Б9-1
2 x Steel Assembly | RIGID_FRAME | 4М-4
2 x Steel Assembly | RIGID_FRAME | 4ПП-3
Steel Assembly | RIGID_FRAME | 4П2-3
5 x Steel Assembly | RIGID_FRAME | 4П2-2
5 x Steel Assembly | RIGID_FRAME | 3П2-16
Steel Assembly | RIGID_FRAME | 4П2-1
Steel Assembly | RIGID_FRAME | 3П2-15
14 x Steel Assembly | RIGID_FRAME | 4СВ1-2
14 x Steel Assembly | RIGID_FRAME | 4СВ1-1
6 x Steel Assembly | RIGID_FRAME | 4РС6-1
128 x Steel Assembly | RIGID_FRAME | 4Ш-1
Steel Assembly | RIGID_FRAME | 3П2-14
16 x Steel Assembly | RIGID_FRAME | 3СВ1-2
16 x Steel Assembly | RIGID_FRAME | 3СВ1-1
8 x Steel Assembly | RIGID_FRAME | 3РС6-1
128 x Steel Assembly | RIGID_FRAME | 3Ш-1
40 x Steel Assembly | RIGID_FRAME | 4М-1
40 x Steel Assembly | RIGID_FRAME | 3М-1
Steel Assembly | RIGID_FRAME | 3П2-3
5 x Steel Assembly | RIGID_FRAME | 3П2-2
12 x Steel Assembly | RIGID_FRAME | 2П2-1
Steel Assembly | RIGID_FRAME | 3П2-1
12 x Steel Assembly | RIGID_FRAME | 2П2-2
2 x Steel Assembly | RIGID_FRAME | 2П2-8
32 x Steel Assembly | RIGID_FRAME | 2СВ1-2
32 x Steel Assembly | RIGID_FRAME | 2СВ1-1
16 x Steel Assembly | RIGID_FRAME | 2РС6-1
256 x Steel Assembly | RIGID_FRAME | 2Ш-1
80 x Steel Assembly | RIGID_FRAME | 2М-1
2 x Steel Assembly | RIGID_FRAME | 2П2-3
5 x Steel Assembly | RIGID_FRAME | 1П2-15
Steel Assembly | RIGID_FRAME | 1П2-14
Steel Assembly | RIGID_FRAME | 1П2-13
10 x Steel Assembly | RIGID_FRAME | 1СВ1-9
10 x Steel Assembly | RIGID_FRAME | 1СВ1-8
5 x Steel Assembly | RIGID_FRAME | 1РС6-5
2 x Steel Assembly | RIGID_FRAME | 1СВ1-6
2 x Steel Assembly | RIGID_FRAME | 1СВ1-4
Steel Assembly | RIGID_FRAME | 1СВ1-7
Steel Assembly | RIGID_FRAME | 1РС6-4
Steel Assembly | RIGID_FRAME | 1СВ1-5
2 x Steel Assembly | RIGID_FRAME | 4СВ1-3
Steel Assembly | RIGID_FRAME | 4РС6-4

# IfcMechanicalFastener: Bolt assembly (12000)
In: Undefined
Material: Undefined
Name | NominalDiameter (mm) | NominalLength (mm)
156 x Bolt assembly | 16 | 16
8 x Bolt assembly | 20 | 20
434 x Bolt assembly | 16 | 20
4 x Bolt assembly | 20 | 25
542 x Bolt assembly | 16 | 5
2 x Bolt assembly | 20 | 10
26 x Bolt assembly | 24 | 5
2169 x Bolt assembly | 20 | 65
2445 x Bolt assembly | 20 | 70
6 x Bolt assembly | 16 | 10
138 x Bolt assembly | 20 | 75
330 x Bolt assembly | 20 | 85
77 x Bolt assembly | 20 | 120
869 x Bolt assembly | 12 | 45
896 x Bolt assembly | 16 | 55
172 x Bolt assembly | 16 | 60
14 x Bolt assembly | 20 | 12
56 x Bolt assembly | 24 | 20
14 x Bolt assembly | 24 | 30
438 x Bolt assembly | 20 | 80
14 x Bolt assembly | 20 | 90
482 x Bolt assembly | 24 | 65
1268 x Bolt assembly | 20 | 6
4 x Bolt assembly | 16 | 4
130 x Bolt assembly | 16 | 65
2 x Bolt assembly | 20 | 14
22 x Bolt assembly | 24 | 80
21 x Bolt assembly | 20 | 5.2
320 x Bolt assembly | 20 | 150
52 x Bolt assembly | 24 | 85
59 x Bolt assembly | 20 | 130
70 x Bolt assembly | 20 | 95
12 x Bolt assembly | 24 | 90
10 x Bolt assembly | 20 | 105
656 x Bolt assembly | 36 | 20
82 x Bolt assembly | 36 | 40

# IfcMember: Профиль(кв.)120X120X5.0 (58)
In: Undefined
Description: Профиль(кв.)120X120X5.0; Material: STEEL/C245-4
Pset_MemberCommon - LoadBearing: yes
Name | Reference
16 x Связь | 854
2 x Кронштейн | 1551
20 x Кронштейн | 859
4 x Связь | 1548
4 x Связь | 1547
4 x Связь | 1550
4 x Связь | 1549
2 x Связь | 855
2 x Связь | 858

# IfcMember: Профиль(кв.)160X160X6.0 (23)
In: Undefined
Description: Профиль(кв.)160X160X6.0; Material: STEEL/C245-4
Pset_MemberCommon - LoadBearing: yes
Name | Reference
Связь | 520
Связь | 519
Связь | 518
4 x Связь | 1490
4 x Связь | 1489
4 x Связь | 1492
4 x Связь | 1491
2 x Связь | 517
2 x Связь | 516

# IfcMember: Профиль(кв.)180X180X5.0 (190)
In: Undefined
Description: Профиль(кв.)180X180X5.0; Material: STEEL/C245-4
Pset_MemberCommon - LoadBearing: yes
Name | Reference
4 x Связь | 1147
4 x Связь | 1148
2 x Связь | 333
8 x Связь | 1143
8 x Связь | 1144
4 x Связь | 328
2 x Связь | 326
2 x Связь | 327
6 x Связь | 320
72 x Связь | 324
72 x Связь | 325
2 x Связь | 323
2 x Связь | 322
2 x Связь | 321

# IfcMember: Профиль(кв.)250X250X6.0 (10)
In: Undefined
Description: Профиль(кв.)250X250X6.0; Material: STEEL/C245-4
Pset_MemberCommon - LoadBearing: yes
Name | Reference
4 x Связь | 1226
4 x Связь | 1225
2 x Связь | 505

# IfcMember: Труба42.3x2.8 (136)
In: Undefined
Description: Труба42.3x2.8; Material: STEEL/C235
Pset_MemberCommon - LoadBearing: yes
Name | Reference
16 x Ограждение | 1459
4 x Ограждение | 1458
4 x Ограждение | 1455
4 x Ограждение | 1454
30 x Ограждение | 967
10 x Ограждение | 1440
8 x Ограждение | 1451
12 x Ограждение | 1447
4 x Ограждение | 1448
16 x Ограждение | 1441
8 x Ограждение | 1445
8 x Ограждение | 1444
2 x Ограждение | 969
8 x Ограждение | 955
2 x Ограждение | 954

# IfcMember: Уголок100X63X8 (5)
In: Undefined
Description: Уголок100X63X8; Material: STEEL/C245-4
Pset_MemberCommon - LoadBearing: yes
Name | Reference
3 x Ригель фахверка | 1182
Ригель фахверка | 404
Ригель фахверка | 403

# IfcPlate: PL12*290 (40)
In: Undefined
Description: PL12*290; Material: STEEL/C245-4
Pset_PlateCommon - LoadBearing: yes; Reference: 25

# IfcPlate: PL12*80 (207)
In: Undefined
Description: PL12*80; Material: STEEL/C245-4
Pset_PlateCommon - LoadBearing: yes; Reference: 31

# IfcPlate: PL16*100 (48)
In: Undefined
Description: PL16*100; Material: STEEL/C355-5
Pset_PlateCommon - LoadBearing: yes; Reference: 1643

# IfcPlate: PL16*120 (108)
In: Undefined
Description: PL16*120; Material: STEEL/C355-5
Pset_PlateCommon - LoadBearing: yes; Reference: 504

# IfcPlate: PL16*959, Балка
In: Undefined
Description: PL16*959; Material: STEEL/C255-4
Pset_PlateCommon - LoadBearing: yes; Reference: 1642

# IfcPlate: PL20*100 (656)
In: Undefined
Description: PL20*100; Material: STEEL/C255-4
Pset_PlateCommon - LoadBearing: yes; Reference: 311

# IfcPlate: PL20*130 (8)
In: Undefined
Description: PL20*130; Material: STEEL/C355-5
Pset_PlateCommon - LoadBearing: yes; Reference: 1579

# IfcPlate: PL20*230 (434)
In: Undefined
Description: PL20*230; Material: STEEL/C355-5
Pset_PlateCommon - LoadBearing: yes; Reference: 318

# IfcPlate: PL20*280 (12)
In: Undefined
Description: PL20*280; Material: STEEL/C255-4
Pset_PlateCommon - LoadBearing: yes; Reference: 312

# IfcPlate: PL20*80 (56)
In: Undefined
Description: PL20*80; Material: STEEL/C255-4
Pset_PlateCommon - LoadBearing: yes; Reference: 317

# IfcPlate: PL5*120 (108)
In: Undefined
Description: PL5*120; Material: STEEL/C245-4
Pset_PlateCommon - LoadBearing: yes; Reference: 681

# IfcPlate: PL5*230 (434)
In: Undefined
Description: PL5*230; Material: STEEL/C245-4
Pset_PlateCommon - LoadBearing: yes; Reference: 680

# IfcPlate: PL6*230 (12)
In: Undefined
Description: PL6*230; Material: STEEL/C245-4
Pset_PlateCommon - LoadBearing: yes; Reference: 414

# IfcPlate: PL6*270 (118)
In: Undefined
Description: PL6*270; Material: STEEL/C245-4
Pset_PlateCommon - LoadBearing: yes; Reference: 415

# IfcPlate: PL6*40 (120)
In: Undefined
Description: PL6*40; Material: STEEL/C245-4
Pset_PlateCommon - LoadBearing: yes; Reference: 421

# IfcPlate: PL6*50 (120)
In: Undefined
Description: PL6*50; Material: STEEL/C245-4
Pset_PlateCommon - LoadBearing: yes; Reference: 420

# IfcPlate: PL6*90 (130)
In: Undefined
Description: PL6*90; Material: STEEL/C245-4
Pset_PlateCommon - LoadBearing: yes; Reference: 435

# IfcPlate: ПВ13*1000 (5)
In: Undefined
Description: ПВ13*1000; Material: MISCELLANEOUS/ПВ506
Pset_PlateCommon - LoadBearing: yes; Reference: 893

# IfcPlate: ПВ13*220 (9)
In: Undefined
Description: ПВ13*220; Material: MISCELLANEOUS/ПВ506
Pset_PlateCommon - LoadBearing: yes
Name | Reference
8 x Настил | 1435
Настил | 896

# IfcPlate: ПВ13*400 (21)
In: Undefined
Description: ПВ13*400; Material: MISCELLANEOUS/ПВ506
Pset_PlateCommon - LoadBearing: yes
Name | Reference
14 x Настил | 902
7 x Настил | 903

# IfcPlate: ПВ13*530 (24)
In: Undefined
Description: ПВ13*530; Material: MISCELLANEOUS/ПВ506
Pset_PlateCommon - LoadBearing: yes
Name | Reference
4 x Настил | 1430
8 x Настил | 1429
4 x Настил | 1423
4 x Настил | 895
Настил | 898
2 x Настил | 897
Настил | 905

# IfcPlate: ПВ13*770 (10)
In: Undefined
Description: ПВ13*770; Material: MISCELLANEOUS/ПВ506
Pset_PlateCommon - LoadBearing: yes
Name | Reference
8 x Настил | 1422
2 x Настил | 889

# IfcPlate: ПВ13*780 (43)
In: Undefined
Description: ПВ13*780; Material: MISCELLANEOUS/ПВ506
Pset_PlateCommon - LoadBearing: yes
Name | Reference
8 x Настил | 1426
8 x Настил | 1434
2 x Настил | 1420
4 x Настил | 1433
6 x Настил | 1425
6 x Настил | 1432
8 x Настил | 1424
Настил | 904

# IfcPlate: ПВ13*800 (2)
In: Undefined
Description: ПВ13*800; Material: MISCELLANEOUS/ПВ506
Pset_PlateCommon - LoadBearing: yes; Reference: 1427

# IfcPlate: ПВ13*980 (84)
In: Undefined
Description: ПВ13*980; Material: MISCELLANEOUS/ПВ506
Pset_PlateCommon - LoadBearing: yes
Name | Reference
4 x Настил | 1431
15 x Настил | 906
15 x Настил | 901
8 x Настил | 894
5 x Настил | 892
10 x Настил | 890
10 x Настил | 888
4 x Настил | 1428
5 x Настил | 882
4 x Настил | 1421
Настил | 891
Настил | 887
Настил | 886
Настил | 885

# IfcPlate: Риф4*1315, Площадка
In: Undefined
Description: Риф4*1315; Material: MISCELLANEOUS/Риф4
Pset_PlateCommon - LoadBearing: yes; Reference: 674

# IfcPlate: Риф4*1380 (2)
In: Undefined
Description: Риф4*1380; Material: MISCELLANEOUS/Риф4
Pset_PlateCommon - LoadBearing: yes
Name | Reference
Площадка | 676
Площадка | 675

# IfcPlate: Риф4*431 (40)
In: Undefined
Description: Риф4*431; Material: MISCELLANEOUS/Риф4
Pset_PlateCommon - LoadBearing: yes
Name | Reference
2 x Щит | 679
2 x Щит | 678
36 x Щит | 677

# IfcPlate: Риф4*590 (4)
In: Undefined
Description: Риф4*590; Material: MISCELLANEOUS/Риф4
Pset_PlateCommon - LoadBearing: yes; Reference: 1707

# IfcPlate: Риф5*1020 (9)
In: Undefined
Description: Риф5*1020; Material: MISCELLANEOUS/Риф5
Pset_PlateCommon - LoadBearing: yes
Name | Reference
Настил | 1762
Настил | 778
2 x Настил | 744
Настил | 760
Настил | 752
Настил | 747
Настил | 741
Настил | 739

# IfcPlate: Риф5*1030 (8)
In: Undefined
Description: Риф5*1030; Material: MISCELLANEOUS/Риф5
Pset_PlateCommon - LoadBearing: yes
Name | Reference
4 x Настил | 1418
2 x Настил | 775
2 x Настил | 770

# IfcPlate: Риф5*1060 (130)
In: Undefined
Description: Риф5*1060; Material: MISCELLANEOUS/Риф5
Pset_PlateCommon - LoadBearing: yes
Name | Reference
Настил | 810
Настил | 731
Настил | 803
Настил | 800
Настил | 722
Настил | 829
10 x Настил | 824
11 x Настил | 791
14 x Настил | 787
14 x Настил | 716
3 x Настил | 1307
3 x Настил | 1415
Настил | 1381
Настил | 1377
13 x Настил | 711
13 x Настил | 707
Настил | 795
Настил | 827
2 x Настил | 1292
2 x Настил | 1348
Настил | 1411
Настил | 1303
Настил | 1365
Настил | 1361
2 x Настил | 1344
2 x Настил | 1288
Настил | 1300
2 x Настил | 1404
Настил | 1356
Настил | 1352
Настил | 1408
Настил | 1296
Настил | 1275
3 x Настил | 1284
Настил | 1271
2 x Настил | 1712
Настил | 1736
2 x Настил | 1724
Настил | 1797
2 x Настил | 1783
Настил | 1732
Настил | 1750
Настил | 1794
2 x Настил | 1728
Настил | 1709
Настил | 1791

# IfcPlate: Риф5*1070 (11)
In: Undefined
Description: Риф5*1070; Material: MISCELLANEOUS/Риф5
Pset_PlateCommon - LoadBearing: yes
Name | Reference
2 x Настил | 1766
2 x Настил | 1764
Настил | 815
Настил | 817
Настил | 812
Настил | 808
Настил | 806
Настил | 798
Настил | 819

# IfcPlate: Риф5*1080 (5)
In: Undefined
Description: Риф5*1080; Material: MISCELLANEOUS/Риф5
Pset_PlateCommon - LoadBearing: yes
Name | Reference
Настил | 1788
Настил | 1802
Настил | 1786
Настил | 1780
Настил | 1804

# IfcPlate: Риф5*1110 (4)
In: Undefined
Description: Риф5*1110; Material: MISCELLANEOUS/Риф5
Pset_PlateCommon - LoadBearing: yes
Name | Reference
2 x Настил | 776
2 x Настил | 771

# IfcPlate: Риф5*1140 (130)
In: Undefined
Description: Риф5*1140; Material: MISCELLANEOUS/Риф5
Pset_PlateCommon - LoadBearing: yes
Name | Reference
Настил | 811
Настил | 732
Настил | 804
Настил | 801
Настил | 723
Настил | 830
11 x Настил | 825
11 x Настил | 792
14 x Настил | 788
14 x Настил | 717
3 x Настил | 1308
3 x Настил | 1416
Настил | 1382
Настил | 1378
13 x Настил | 712
13 x Настил | 708
Настил | 796
2 x Настил | 1293
2 x Настил | 1349
Настил | 1412
Настил | 1304
Настил | 1366
Настил | 1362
2 x Настил | 1345
2 x Настил | 1289
Настил | 1301
2 x Настил | 1405
Настил | 1357
Настил | 1353
Настил | 1409
Настил | 1297
Настил | 1276
3 x Настил | 1285
Настил | 1272
2 x Настил | 1713
Настил | 1737
2 x Настил | 1725
Настил | 1798
2 x Настил | 1784
Настил | 1733
Настил | 1751
Настил | 1795
2 x Настил | 1729
Настил | 1710
Настил | 1792

# IfcPlate: Риф5*1150 (7)
In: Undefined
Description: Риф5*1150; Material: MISCELLANEOUS/Риф5
Pset_PlateCommon - LoadBearing: yes
Name | Reference
Настил | 816
Настил | 818
Настил | 813
Настил | 809
Настил | 807
Настил | 799
Настил | 820

# IfcPlate: Риф5*1160 (5)
In: Undefined
Description: Риф5*1160; Material: MISCELLANEOUS/Риф5
Pset_PlateCommon - LoadBearing: yes
Name | Reference
Настил | 1789
Настил | 1803
Настил | 1787
Настил | 1781
Настил | 1805

# IfcPlate: Риф5*1220 (2)
In: Undefined
Description: Риф5*1220; Material: MISCELLANEOUS/Риф5
Pset_PlateCommon - LoadBearing: yes; Reference: 1775

# IfcPlate: Риф5*130 (2)
In: Undefined
Description: Риф5*130; Material: MISCELLANEOUS/Риф5
Pset_PlateCommon - LoadBearing: yes
Name | Reference
Настил | 692
Настил | 686

# IfcPlate: Риф5*240 (4)
In: Undefined
Description: Риф5*240; Material: MISCELLANEOUS/Риф5
Pset_PlateCommon - LoadBearing: yes
Name | Reference
Настил | 757
Настил | 756
Настил | 755
Настил | 685

# IfcPlate: Риф5*290 (8)
In: Undefined
Description: Риф5*290; Material: MISCELLANEOUS/Риф5
Pset_PlateCommon - LoadBearing: yes; Reference: 1331

# IfcPlate: Риф5*300 (4)
In: Undefined
Description: Риф5*300; Material: MISCELLANEOUS/Риф5
Pset_PlateCommon - LoadBearing: yes; Reference: 1800

# IfcPlate: Риф5*320, Настил
In: Undefined
Description: Риф5*320; Material: MISCELLANEOUS/Риф5
Pset_PlateCommon - LoadBearing: yes; Reference: 767

# IfcPlate: Риф5*340, Настил
In: Undefined
Description: Риф5*340; Material: MISCELLANEOUS/Риф5
Pset_PlateCommon - LoadBearing: yes; Reference: 1722

# IfcPlate: Риф5*360 (6)
In: Undefined
Description: Риф5*360; Material: MISCELLANEOUS/Риф5
Pset_PlateCommon - LoadBearing: yes
Name | Reference
3 x Настил | 1334
2 x Настил | 1399
Настил | 1374

# IfcPlate: Риф5*370, Настил
In: Undefined
Description: Риф5*370; Material: MISCELLANEOUS/Риф5
Pset_PlateCommon - LoadBearing: yes; Reference: 1747

# IfcPlate: Риф5*390 (11)
In: Undefined
Description: Риф5*390; Material: MISCELLANEOUS/Риф5
Pset_PlateCommon - LoadBearing: yes
Name | Reference
3 x Настил | 1419
Настил | 1322
Настил | 737
Настил | 696
Настил | 694
Настил | 688
2 x Настил | 728
Настил | 734

# IfcPlate: Риф5*410 (16)
In: Undefined
Description: Риф5*410; Material: MISCELLANEOUS/Риф5
Pset_PlateCommon - LoadBearing: yes
Name | Reference
Настил | 684
2 x Настил | 1396
8 x Настил | 1330
2 x Настил | 1395
Настил | 1315
Настил | 1373
Настил | 1741

# IfcPlate: Риф5*440 (2)
In: Undefined
Description: Риф5*440; Material: MISCELLANEOUS/Риф5
Pset_PlateCommon - LoadBearing: yes; Reference: 1757

# IfcPlate: Риф5*450 (3)
In: Undefined
Description: Риф5*450; Material: MISCELLANEOUS/Риф5
Pset_PlateCommon - LoadBearing: yes
Name | Reference
2 x Настил | 1776
Настил | 785

# IfcPlate: Риф5*490 (3)
In: Undefined
Description: Риф5*490; Material: MISCELLANEOUS/Риф5
Pset_PlateCommon - LoadBearing: yes
Name | Reference
2 x Настил | 765
Настил | 754

# IfcPlate: Риф5*500 (12)
In: Undefined
Description: Риф5*500; Material: MISCELLANEOUS/Риф5
Pset_PlateCommon - LoadBearing: yes
Name | Reference
Настил | 784
Настил | 783
Настил | 703
Настил | 702
Настил | 701
Настил | 700
Настил | 699
Настил | 698
Настил | 697
Настил | 782
Настил | 781
Настил | 1756

# IfcPlate: Риф5*550 (4)
In: Undefined
Description: Риф5*550; Material: MISCELLANEOUS/Риф5
Pset_PlateCommon - LoadBearing: yes
Name | Reference
Настил | 1773
Настил | 695
Настил | 693
Настил | 727

# IfcPlate: Риф5*570, Настил
In: Undefined
Description: Риф5*570; Material: MISCELLANEOUS/Риф5
Pset_PlateCommon - LoadBearing: yes; Reference: 750

# IfcPlate: Риф5*640 (15)
In: Undefined
Description: Риф5*640; Material: MISCELLANEOUS/Риф5
Pset_PlateCommon - LoadBearing: yes
Name | Reference
Настил | 1320
Настил | 1281
Настил | 1340
4 x Настил | 1282
2 x Настил | 1392
2 x Настил | 1391
Настил | 1370
Настил | 1369
Настил | 1717
Настил | 1739

# IfcPlate: Риф5*650, Настил
In: Undefined
Description: Риф5*650; Material: MISCELLANEOUS/Риф5
Pset_PlateCommon - LoadBearing: yes; Reference: 758

# IfcPlate: Риф5*690 (60)
In: Undefined
Description: Риф5*690; Material: MISCELLANEOUS/Риф5
Pset_PlateCommon - LoadBearing: yes
Name | Reference
10 x Настил | 826
Настил | 726
3 x Настил | 1309
Настил | 1383
13 x Настил | 713
12 x Настил | 789
Настил | 1413
Настил | 1367
2 x Настил | 1346
Настил | 1302
Настил | 1358
Настил | 1410
Настил | 1294
Настил | 1277
3 x Настил | 1286
Настил | 1715
2 x Настил | 1726
2 x Настил | 1785
2 x Настил | 1730
Настил | 1793

# IfcPlate: Риф5*720 (2)
In: Undefined
Description: Риф5*720; Material: MISCELLANEOUS/Риф5
Pset_PlateCommon - LoadBearing: yes
Name | Reference
Настил | 822
Настил | 753

# IfcPlate: Риф5*740 (10)
In: Undefined
Description: Риф5*740; Material: MISCELLANEOUS/Риф5
Pset_PlateCommon - LoadBearing: yes
Name | Reference
3 x Настил | 1769
2 x Настил | 1772
Настил | 1771
Настил | 1770
2 x Настил | 1767
Настил | 1768

# IfcPlate: Риф5*750, Настил
In: Undefined
Description: Риф5*750; Material: MISCELLANEOUS/Риф5
Pset_PlateCommon - LoadBearing: yes; Reference: 821
