Properties of the parts of a building model (IFC2X3), part 3 of 3

# IfcPlate: Риф5*760 (2)
In: Undefined
Description: Риф5*760; Material: MISCELLANEOUS/Риф5
Pset_PlateCommon - LoadBearing: yes
Name | Reference
Настил | 779
Настил | 773

# IfcPlate: Риф5*770 (5)
In: Undefined
Description: Риф5*770; Material: MISCELLANEOUS/Риф5
Pset_PlateCommon - LoadBearing: yes
Name | Reference
Настил | 761
Настил | 748
Настил | 745
Настил | 742
Настил | 740

# IfcPlate: Риф5*780 (2)
In: Undefined
Description: Риф5*780; Material: MISCELLANEOUS/Риф5
Pset_PlateCommon - LoadBearing: yes
Name | Reference
Настил | 687
Настил | 683

# IfcPlate: Риф5*800 (70)
In: Undefined
Description: Риф5*800; Material: MISCELLANEOUS/Риф5
Pset_PlateCommon - LoadBearing: yes
Name | Reference
Настил | 730
Настил | 802
Настил | 721
Настил | 828
2 x Настил | 1401
2 x Настил | 1400
2 x Настил | 1339
3 x Настил | 1328
Настил | 1388
Настил | 1387
3 x Настил | 1414
Настил | 1376
Настил | 1329
Настил | 1742
Настил | 1720
13 x Настил | 706
Настил | 794
9 x Настил | 790
12 x Настил | 715
Настил | 1360
2 x Настил | 1287
2 x Настил | 1403
Настил | 1351
Настил | 1295
Настил | 1347
Настил | 1270
Настил | 1735
Настил | 1796
Настил | 1731
Настил | 1708

# IfcPlate: Риф5*820, Настил
In: Undefined
Description: Риф5*820; Material: MISCELLANEOUS/Риф5
Pset_PlateCommon - LoadBearing: yes; Reference: 704

# IfcPlate: Риф5*830 (160)
In: Undefined
Description: Риф5*830; Material: MISCELLANEOUS/Риф5
Pset_PlateCommon - LoadBearing: yes
Name | Reference
Настил | 1746
Настил | 1758
Настил | 1721
3 x Настил | 1716
Настил | 1801
36 x Настил | 738
2 x Настил | 780
4 x Настил | 746
2 x Настил | 762
Настил | 682
Настил | 749
Настил | 729
2 x Настил | 743
2 x Настил | 719
2 x Настил | 1319
4 x Настил | 1313
2 x Настил | 1318
4 x Настил | 1311
Настил | 1280
2 x Настил | 1279
Настил | 1314
3 x Настил | 1333
3 x Настил | 1385
Настил | 1332
Настил | 1375
2 x Настил | 1312
2 x Настил | 1278
Настил | 1719
35 x Настил | 705
2 x Настил | 1324
Настил | 1359
18 x Настил | 1323
17 x Настил | 1341

# IfcPlate: Риф5*840, Настил
In: Undefined
Description: Риф5*840; Material: MISCELLANEOUS/Риф5
Pset_PlateCommon - LoadBearing: yes; Reference: 1759

# IfcPlate: Риф5*860 (71)
In: Undefined
Description: Риф5*860; Material: MISCELLANEOUS/Риф5
Pset_PlateCommon - LoadBearing: yes
Name | Reference
Настил | 751
Настил | 733
Настил | 805
Настил | 724
Настил | 831
Настил | 1321
2 x Настил | 1397
2 x Настил | 1337
3 x Настил | 1326
Настил | 1398
Настил | 1335
Настил | 1389
3 x Настил | 1417
Настил | 1379
2 x Настил | 1327
Настил | 1744
13 x Настил | 709
Настил | 797
9 x Настил | 793
12 x Настил | 718
Настил | 1363
2 x Настил | 1290
2 x Настил | 1406
Настил | 1354
Настил | 1298
Настил | 1350
Настил | 1273
Настил | 1738
Настил | 1799
Настил | 1734
Настил | 1711

# IfcPlate: Риф5*870 (4)
In: Undefined
Description: Риф5*870; Material: MISCELLANEOUS/Риф5
Pset_PlateCommon - LoadBearing: yes
Name | Reference
Настил | 1760
Настил | 1778
Настил | 774
Настил | 769

# IfcPlate: Риф5*880 (7)
In: Undefined
Description: Риф5*880; Material: MISCELLANEOUS/Риф5
Pset_PlateCommon - LoadBearing: yes
Name | Reference
Настил | 1755
Настил | 1754
5 x Настил | 1748

# IfcPlate: Риф5*900 (17)
In: Undefined
Description: Риф5*900; Material: MISCELLANEOUS/Риф5
Pset_PlateCommon - LoadBearing: yes
Name | Reference
8 x Настил | 1774
8 x Настил | 1779
Настил | 1777

# IfcPlate: Риф5*910 (62)
In: Undefined
Description: Риф5*910; Material: MISCELLANEOUS/Риф5
Pset_PlateCommon - LoadBearing: yes
Name | Reference
36 x Настил | 714
2 x Настил | 720
3 x Настил | 1386
Настил | 1384
2 x Настил | 1368
18 x Настил | 1342

# IfcPlate: Риф5*940 (77)
In: Undefined
Description: Риф5*940; Material: MISCELLANEOUS/Риф5
Pset_PlateCommon - LoadBearing: yes
Name | Reference
Настил | 1761
Настил | 777
Настил | 772
Настил | 759
Настил | 725
2 x Настил | 1317
2 x Настил | 1338
2 x Настил | 1394
2 x Настил | 1393
Настил | 1316
Настил | 1390
3 x Настил | 1306
Настил | 1380
Настил | 1372
Настил | 1371
Настил | 1745
Настил | 1743
Настил | 1718
Настил | 1740
13 x Настил | 710
9 x Настил | 823
12 x Настил | 786
Настил | 1364
2 x Настил | 1343
Настил | 1299
Настил | 1355
Настил | 1407
Настил | 1291
Настил | 1274
2 x Настил | 1283
Настил | 1714
2 x Настил | 1723
2 x Настил | 1782
2 x Настил | 1727
Настил | 1790

# IfcPlate: Риф5*950 (7)
In: Undefined
Description: Риф5*950; Material: MISCELLANEOUS/Риф5
Pset_PlateCommon - LoadBearing: yes
Name | Reference
Настил | 1753
Настил | 1752
5 x Настил | 1749

# IfcPlate: Риф5*960 (11)
In: Undefined
Description: Риф5*960; Material: MISCELLANEOUS/Риф5
Pset_PlateCommon - LoadBearing: yes
Name | Reference
Настил | 814
3 x Настил | 1336
Настил | 1310
4 x Настил | 1305
2 x Настил | 1325

# IfcPlate: Риф5*990 (4)
In: Undefined
Description: Риф5*990; Material: MISCELLANEOUS/Риф5
Pset_PlateCommon - LoadBearing: yes
Name | Reference
2 x Настил | 1765
2 x Настил | 1763
